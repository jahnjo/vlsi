*  Spice netlist DFFen.pex.netlist transformed for AMS-Sim
*    additions

.LIB $MGC_DESIGN_KIT/models/lib.eldo TT

Vvdd VDD 0 2.5
Vgnd ground 0 0

*  Here begins the original spice file

* File: DFFen.pex.netlist
* Created: Mon Apr 15 16:21:46 2019
* Program "Calibre xRC"
* Version "v2012.2_36.25"
*
.global VDD VSS
.include "DFFen.pex.netlist.pex"
*
* CLK	CLK
* EN	EN
* GROUND	GROUND
* D	D
* Q	Q
* VDD	VDD
M0 N_3_M0_d N_6_M0_g N_Q_M0_s N_GROUND_M0_b NMOS L=1.3e-07 W=6e-07
M1 N_D_M1_d N_EN_M1_g N_3_M0_d N_GROUND_M0_b NMOS L=1.3e-07 W=6e-07
M2 N_6_M2_d N_EN_M2_g N_GROUND_M2_s N_GROUND_M0_b NMOS L=1.3e-07 W=6e-07
M3 N_GROUND_M3_d N_11_M3_g N_Q_M3_s N_GROUND_M0_b NMOS L=1.3e-07 W=6e-07
M4 N_7_M4_d N_10_M4_g N_GROUND_M3_d N_GROUND_M0_b NMOS L=1.3e-07 W=6e-07
M5 8 N_15_M5_g N_7_M4_d N_GROUND_M0_b NMOS L=1.3e-07 W=6e-07
M6 N_GROUND_M6_d N_3_M6_g 8 N_GROUND_M0_b NMOS L=1.3e-07 W=6e-07
M7 9 N_14_M7_g N_GROUND_M6_d N_GROUND_M0_b NMOS L=1.3e-07 W=6e-07
M8 N_10_M8_d N_15_M8_g 9 N_GROUND_M0_b NMOS L=1.3e-07 W=6e-07
M9 N_GROUND_M9_d N_7_M9_g N_10_M8_d N_GROUND_M0_b NMOS L=1.3e-07 W=6e-07
M10 N_11_M10_d N_Q_M10_g N_GROUND_M9_d N_GROUND_M0_b NMOS L=1.3e-07 W=6e-07
M11 12 N_CLK_M11_g N_11_M11_s N_GROUND_M0_b NMOS L=1.3e-07 W=6e-07
M12 N_GROUND_M12_d N_10_M12_g 12 N_GROUND_M0_b NMOS L=1.3e-07 W=6e-07
M13 13 N_7_M13_g N_GROUND_M12_d N_GROUND_M0_b NMOS L=1.3e-07 W=6e-07
M14 N_Q_M14_d N_CLK_M14_g 13 N_GROUND_M0_b NMOS L=1.3e-07 W=6e-07
M15 N_GROUND_M15_d N_3_M15_g N_14_M15_s N_GROUND_M0_b NMOS L=1.3e-07 W=6e-07
M16 N_15_M16_d N_CLK_M16_g N_GROUND_M15_d N_GROUND_M0_b NMOS L=1.3e-07 W=6e-07
M17 N_3_M17_d N_EN_M17_g N_Q_M17_s N_VDD_M17_b PMOS L=1.3e-07 W=1.35e-06
M18 N_D_M18_d N_6_M18_g N_3_M17_d N_VDD_M17_b PMOS L=1.3e-07 W=1.35e-06
M19 N_6_M19_d N_EN_M19_g N_VDD_M19_s N_VDD_M17_b PMOS L=1.3e-07 W=1.35e-06
M20 N_VDD_M20_d N_3_M20_g N_14_M20_s N_VDD_M17_b PMOS L=1.3e-07 W=6e-07
M21 N_15_M21_d N_CLK_M21_g N_VDD_M20_d N_VDD_M17_b PMOS L=1.3e-07 W=6e-07
M22 N_VDD_M22_d N_7_M22_g N_10_M22_s N_VDD_M17_b PMOS L=1.3e-07 W=6e-07
M23 N_7_M23_d N_10_M23_g N_VDD_M22_d N_VDD_M17_b PMOS L=1.3e-07 W=6e-07
M24 N_VDD_M24_d N_11_M24_g N_Q_M24_s N_VDD_M17_b PMOS L=1.3e-07 W=6e-07
M25 N_11_M25_d N_Q_M25_g N_VDD_M24_d N_VDD_M17_b PMOS L=1.3e-07 W=6e-07
*
.include "DFFen.pex.netlist.DFFEN.pxi"
*
.End
*
*
