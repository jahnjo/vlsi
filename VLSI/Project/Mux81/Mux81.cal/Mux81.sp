*  Spice netlist Mux81.pex.netlist transformed for AMS-Sim
*    additions

.LIB $MGC_DESIGN_KIT/models/lib.eldo TT

Vvdd VDD 0 2.5
Vgnd ground 0 0

*  Here begins the original spice file

* File: Mux81.pex.netlist
* Created: Mon Apr 15 15:27:51 2019
* Program "Calibre xRC"
* Version "v2012.2_36.25"
*
.global VDD VSS
.include "Mux81.pex.netlist.pex"
*
* S2	S2
* OUT1	OUT1
* S1	S1
* IN7	IN7
* IN6	IN6
* S0	S0
* IN5	IN5
* IN4	IN4
* IN3	IN3
* IN2	IN2
* IN1	IN1
* IN0	IN0
* GROUND	GROUND
* VDD	VDD
mX0_M0 N_4_X0_M0_d N_X0_7_X0_M0_g N_IN0_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07
+ W=6e-07
mX0_M1 N_IN1_X0_M1_d N_S0_X0_M1_g N_4_X0_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07
+ W=6e-07
mX0_M2 N_X0_7_X0_M2_d N_S0_X0_M2_g N_GROUND_X0_M2_s N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX0_M3 N_4_X0_M3_d N_S0_X0_M3_g N_IN0_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX0_M4 N_IN1_X0_M4_d N_X0_7_X0_M4_g N_4_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX0_M5 N_X0_7_X0_M5_d N_S0_X0_M5_g N_VDD_X0_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX1_M0 N_8_X1_M0_d N_X1_7_X1_M0_g N_IN2_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07
+ W=6e-07
mX1_M1 N_IN3_X1_M1_d N_S0_X1_M1_g N_8_X1_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07
+ W=6e-07
mX1_M2 N_X1_7_X1_M2_d N_S0_X1_M2_g N_GROUND_X1_M2_s N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX1_M3 N_8_X1_M3_d N_S0_X1_M3_g N_IN2_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX1_M4 N_IN3_X1_M4_d N_X1_7_X1_M4_g N_8_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX1_M5 N_X1_7_X1_M5_d N_S0_X1_M5_g N_VDD_X1_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX2_M0 N_17_X2_M0_d N_X2_7_X2_M0_g N_4_X2_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07
+ W=6e-07
mX2_M1 N_8_X2_M1_d N_S1_X2_M1_g N_17_X2_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07
+ W=6e-07
mX2_M2 N_X2_7_X2_M2_d N_S1_X2_M2_g N_GROUND_X2_M2_s N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX2_M3 N_17_X2_M3_d N_S1_X2_M3_g N_4_X2_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX2_M4 N_8_X2_M4_d N_X2_7_X2_M4_g N_17_X2_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX2_M5 N_X2_7_X2_M5_d N_S1_X2_M5_g N_VDD_X2_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX3_M0 N_10_X3_M0_d N_X3_7_X3_M0_g N_IN4_X3_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07
+ W=6e-07
mX3_M1 N_IN5_X3_M1_d N_S0_X3_M1_g N_10_X3_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07
+ W=6e-07
mX3_M2 N_X3_7_X3_M2_d N_S0_X3_M2_g N_GROUND_X3_M2_s N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX3_M3 N_10_X3_M3_d N_S0_X3_M3_g N_IN4_X3_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX3_M4 N_IN5_X3_M4_d N_X3_7_X3_M4_g N_10_X3_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX3_M5 N_X3_7_X3_M5_d N_S0_X3_M5_g N_VDD_X3_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX4_M0 N_15_X4_M0_d N_X4_7_X4_M0_g N_IN6_X4_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07
+ W=6e-07
mX4_M1 N_IN7_X4_M1_d N_S0_X4_M1_g N_15_X4_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07
+ W=6e-07
mX4_M2 N_X4_7_X4_M2_d N_S0_X4_M2_g N_GROUND_X4_M2_s N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX4_M3 N_15_X4_M3_d N_S0_X4_M3_g N_IN6_X4_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX4_M4 N_IN7_X4_M4_d N_X4_7_X4_M4_g N_15_X4_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX4_M5 N_X4_7_X4_M5_d N_S0_X4_M5_g N_VDD_X4_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX5_M0 N_19_X5_M0_d N_X5_7_X5_M0_g N_10_X5_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07
+ W=6e-07
mX5_M1 N_15_X5_M1_d N_S1_X5_M1_g N_19_X5_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07
+ W=6e-07
mX5_M2 N_X5_7_X5_M2_d N_S1_X5_M2_g N_GROUND_X5_M2_s N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX5_M3 N_19_X5_M3_d N_S1_X5_M3_g N_10_X5_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX5_M4 N_15_X5_M4_d N_X5_7_X5_M4_g N_19_X5_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX5_M5 N_X5_7_X5_M5_d N_S1_X5_M5_g N_VDD_X5_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX6_M0 N_OUT1_X6_M0_d N_X6_7_X6_M0_g N_17_X6_M0_s N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX6_M1 N_19_X6_M1_d N_S2_X6_M1_g N_OUT1_X6_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07
+ W=6e-07
mX6_M2 N_X6_7_X6_M2_d N_S2_X6_M2_g N_GROUND_X6_M2_s N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX6_M3 N_OUT1_X6_M3_d N_S2_X6_M3_g N_17_X6_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX6_M4 N_19_X6_M4_d N_X6_7_X6_M4_g N_OUT1_X6_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX6_M5 N_X6_7_X6_M5_d N_S2_X6_M5_g N_VDD_X6_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
*
.include "Mux81.pex.netlist.MUX81.pxi"
*
.End
*
*
