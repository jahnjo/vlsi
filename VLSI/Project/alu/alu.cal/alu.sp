*  Spice netlist alu.pex.netlist transformed for AMS-Sim
*    additions

.LIB $MGC_DESIGN_KIT/models/lib.eldo TT

Vvdd VDD 0 2.5
Vgnd ground 0 0

*  Here begins the original spice file

* File: alu.pex.netlist
* Created: Mon Apr 15 14:11:22 2019
* Program "Calibre xRC"
* Version "v2012.2_36.25"
*
.global VDD VSS
.include "alu.pex.netlist.pex"
*
* ALUOP_1	ALUOP_1
* RESULT	RESULT
* ALUOP_0	ALUOP_0
* CIN	CIN
* A	A
* B	B
* COUT	COUT
* GROUND	GROUND
* VDD	VDD
M0 N_3_M0_d N_B_M0_g N_GROUND_M0_s N_GROUND_X42_M0_b NMOS L=1.3e-07 W=6e-07
M1 N_4_M1_d N_B_M1_g N_GROUND_M1_s N_GROUND_X42_M0_b NMOS L=1.3e-07 W=6e-07
M2 N_GROUND_M2_d N_A_M2_g N_4_M1_d N_GROUND_X42_M0_b NMOS L=1.3e-07 W=6e-07
M3 N_5_M3_d N_4_M3_g N_GROUND_M2_d N_GROUND_X42_M0_b NMOS L=1.3e-07 W=6e-07
M4 7 N_A_M4_g N_6_M4_s N_GROUND_X42_M0_b NMOS L=1.3e-07 W=1.2e-06
M5 N_GROUND_M5_d N_B_M5_g 7 N_GROUND_X42_M0_b NMOS L=1.3e-07 W=1.2e-06
M6 N_8_M6_d N_6_M6_g N_GROUND_M5_d N_GROUND_X42_M0_b NMOS L=1.3e-07 W=6e-07
M7 10 N_CIN_M7_g N_9_M7_s N_GROUND_X42_M0_b NMOS L=1.3e-07 W=2e-06
M8 11 N_27_M8_g 10 N_GROUND_X42_M0_b NMOS L=1.3e-07 W=2e-06
M9 N_GROUND_M9_d N_A_M9_g 11 N_GROUND_X42_M0_b NMOS L=1.3e-07 W=2e-06
M10 N_COUT_M10_d N_16_M10_g N_GROUND_M9_d N_GROUND_X42_M0_b NMOS L=1.3e-07
+ W=2e-06
M11 N_GROUND_M11_d N_9_M11_g N_13_M11_s N_GROUND_X42_M0_b NMOS L=1.3e-07 W=2e-06
M12 N_14_M12_d N_CIN_M12_g N_GROUND_M11_d N_GROUND_X42_M0_b NMOS L=1.3e-07
+ W=2e-06
M13 N_GROUND_M13_d N_27_M13_g N_14_M12_d N_GROUND_X42_M0_b NMOS L=1.3e-07
+ W=2e-06
M14 N_14_M14_d N_A_M14_g N_GROUND_M13_d N_GROUND_X42_M0_b NMOS L=1.3e-07 W=2e-06
M15 N_9_M15_d N_16_M15_g N_14_M14_d N_GROUND_X42_M0_b NMOS L=1.3e-07 W=2e-06
M16 N_15_M16_d N_27_M16_g N_GROUND_M16_s N_GROUND_X42_M0_b NMOS L=1.3e-07
+ W=2e-06
M17 N_16_M17_d N_CIN_M17_g N_15_M16_d N_GROUND_X42_M0_b NMOS L=1.3e-07 W=2e-06
M18 17 N_A_M18_g N_16_M17_d N_GROUND_X42_M0_b NMOS L=1.3e-07 W=2e-06
M19 N_GROUND_M19_d N_27_M19_g 17 N_GROUND_X42_M0_b NMOS L=1.3e-07 W=2e-06
M20 N_15_M20_d N_A_M20_g N_GROUND_M19_d N_GROUND_X42_M0_b NMOS L=1.3e-07 W=2e-06
M21 N_3_M21_d N_B_M21_g N_VDD_M21_s N_VDD_X42_M3_b PMOS L=1.3e-07 W=1.35e-06
M22 N_VDD_M22_d N_4_M22_g N_5_M22_s N_VDD_X43_M3_b PMOS L=1.3e-07 W=1.35e-06
M23 18 N_A_M23_g N_VDD_M22_d N_VDD_X43_M3_b PMOS L=1.3e-07 W=2.7e-06
M24 N_4_M24_d N_B_M24_g 18 N_VDD_X43_M3_b PMOS L=1.3e-07 W=2.7e-06
M25 N_6_M25_d N_A_M25_g N_VDD_M25_s N_VDD_X43_M3_b PMOS L=1.3e-07 W=1.35e-06
M26 N_VDD_M26_d N_B_M26_g N_6_M25_d N_VDD_X43_M3_b PMOS L=1.3e-07 W=1.35e-06
M27 N_8_M27_d N_6_M27_g N_VDD_M26_d N_VDD_X43_M3_b PMOS L=1.3e-07 W=1.35e-06
M28 N_16_M28_d N_CIN_M28_g N_19_M28_s N_VDD_X42_M3_b PMOS L=1.3e-07 W=2e-06
M29 20 N_A_M29_g N_16_M28_d N_VDD_X42_M3_b PMOS L=1.3e-07 W=2e-06
M30 N_VDD_M30_d N_27_M30_g 20 N_VDD_X42_M3_b PMOS L=1.3e-07 W=2e-06
M31 N_19_M31_d N_27_M31_g N_VDD_M30_d N_VDD_X42_M3_b PMOS L=1.3e-07 W=2e-06
M32 N_VDD_M32_d N_A_M32_g N_19_M31_d N_VDD_X42_M3_b PMOS L=1.3e-07 W=2e-06
M33 21 N_A_M33_g N_VDD_M32_d N_VDD_X42_M3_b PMOS L=1.3e-07 W=2e-06
M34 22 N_27_M34_g 21 N_VDD_X42_M3_b PMOS L=1.3e-07 W=2e-06
M35 N_9_M35_d N_CIN_M35_g 22 N_VDD_X42_M3_b PMOS L=1.3e-07 W=2e-06
M36 N_23_M36_d N_16_M36_g N_9_M35_d N_VDD_X42_M3_b PMOS L=1.3e-07 W=2e-06
M37 N_VDD_M37_d N_16_M37_g N_COUT_M37_s N_VDD_X42_M3_b PMOS L=1.3e-07 W=2e-06
M38 N_23_M38_d N_A_M38_g N_VDD_M37_d N_VDD_X42_M3_b PMOS L=1.3e-07 W=2e-06
M39 N_VDD_M39_d N_27_M39_g N_23_M38_d N_VDD_X42_M3_b PMOS L=1.3e-07 W=2e-06
M40 N_23_M40_d N_CIN_M40_g N_VDD_M39_d N_VDD_X42_M3_b PMOS L=1.3e-07 W=2e-06
M41 N_13_M41_d N_9_M41_g N_VDD_M41_s N_VDD_X42_M3_b PMOS L=1.3e-07 W=2e-06
mX42_M0 N_27_X42_M0_d N_X42_7_X42_M0_g N_B_X42_M0_s N_GROUND_X42_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX42_M1 N_3_X42_M1_d N_ALUOP_0_X42_M1_g N_27_X42_M0_d N_GROUND_X42_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX42_M2 N_X42_7_X42_M2_d N_ALUOP_0_X42_M2_g N_GROUND_X42_M2_s N_GROUND_X42_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX42_M3 N_27_X42_M3_d N_ALUOP_0_X42_M3_g N_B_X42_M3_s N_VDD_X42_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX42_M4 N_3_X42_M4_d N_X42_7_X42_M4_g N_27_X42_M3_d N_VDD_X42_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX42_M5 N_X42_7_X42_M5_d N_ALUOP_0_X42_M5_g N_VDD_X42_M5_s N_VDD_X42_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX43_M0 N_29_X43_M0_d N_X43_7_X43_M0_g N_13_X43_M0_s N_GROUND_X42_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX43_M1 N_13_X43_M1_d N_ALUOP_0_X43_M1_g N_29_X43_M0_d N_GROUND_X42_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX43_M2 N_X43_7_X43_M2_d N_ALUOP_0_X43_M2_g N_GROUND_X43_M2_s N_GROUND_X42_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX43_M3 N_29_X43_M3_d N_ALUOP_0_X43_M3_g N_13_X43_M3_s N_VDD_X43_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX43_M4 N_13_X43_M4_d N_X43_7_X43_M4_g N_29_X43_M3_d N_VDD_X43_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX43_M5 N_X43_7_X43_M5_d N_ALUOP_0_X43_M5_g N_VDD_X43_M5_s N_VDD_X43_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX44_M0 N_RESULT_X44_M0_d N_X44_7_X44_M0_g N_29_X44_M0_s N_GROUND_X42_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX44_M1 N_32_X44_M1_d N_ALUOP_1_X44_M1_g N_RESULT_X44_M0_d N_GROUND_X42_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX44_M2 N_X44_7_X44_M2_d N_ALUOP_1_X44_M2_g N_GROUND_X44_M2_s N_GROUND_X42_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX44_M3 N_RESULT_X44_M3_d N_ALUOP_1_X44_M3_g N_29_X44_M3_s N_VDD_X43_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX44_M4 N_32_X44_M4_d N_X44_7_X44_M4_g N_RESULT_X44_M3_d N_VDD_X43_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX44_M5 N_X44_7_X44_M5_d N_ALUOP_1_X44_M5_g N_VDD_X44_M5_s N_VDD_X43_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX45_M0 N_32_X45_M0_d N_X45_7_X45_M0_g N_8_X45_M0_s N_GROUND_X42_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX45_M1 N_5_X45_M1_d N_ALUOP_0_X45_M1_g N_32_X45_M0_d N_GROUND_X42_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX45_M2 N_X45_7_X45_M2_d N_ALUOP_0_X45_M2_g N_GROUND_X45_M2_s N_GROUND_X42_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX45_M3 N_32_X45_M3_d N_ALUOP_0_X45_M3_g N_8_X45_M3_s N_VDD_X43_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX45_M4 N_5_X45_M4_d N_X45_7_X45_M4_g N_32_X45_M3_d N_VDD_X43_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX45_M5 N_X45_7_X45_M5_d N_ALUOP_0_X45_M5_g N_VDD_X45_M5_s N_VDD_X43_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
*
.include "alu.pex.netlist.ALU.pxi"
*
.End
*
*
