*  Spice netlist control.pex.netlist transformed for AMS-Sim
*    additions

.LIB $MGC_DESIGN_KIT/models/lib.eldo TT

Vvdd VDD 0 2.5
Vgnd ground 0 0

*  Here begins the original spice file

* File: control.pex.netlist
* Created: Thu Apr 18 12:54:00 2019
* Program "Calibre xRC"
* Version "v2012.2_36.25"
*
.global VDD VSS
.include "control.pex.netlist.pex"
*
* ALU_SRC	ALU_SRC
* ALU_OP_0	ALU_OP_0
* PC_SRC	PC_SRC
* OP_2	OP_2
* ALU_OP_1	ALU_OP_1
* REG_WRITE	REG_WRITE
* OP_1	OP_1
* OP_0	OP_0
* GROUND	GROUND
* VDD	VDD
mX0_X0_M0 X0_X0_7 N_3_X0_X0_M0_g N_X0_X0_6_X0_X0_M0_s N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=1.2e-06
mX0_X0_M1 N_GROUND_X0_X0_M1_d N_4_X0_X0_M1_g X0_X0_7 N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=1.2e-06
mX0_X0_M2 N_X0_7_X0_X0_M2_d N_X0_X0_6_X0_X0_M2_g N_GROUND_X0_X0_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X0_M3 N_X0_X0_6_X0_X0_M3_d N_3_X0_X0_M3_g N_VDD_X0_X0_M3_s N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX0_X0_M4 N_VDD_X0_X0_M4_d N_4_X0_X0_M4_g N_X0_X0_6_X0_X0_M3_d N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX0_X0_M5 N_X0_7_X0_X0_M5_d N_X0_X0_6_X0_X0_M5_g N_VDD_X0_X0_M4_d
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX0_X1_M0 X0_X1_7 N_X0_7_X0_X1_M0_g N_X0_X1_6_X0_X1_M0_s N_GROUND_X0_X0_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX0_X1_M1 N_GROUND_X0_X1_M1_d N_5_X0_X1_M1_g X0_X1_7 N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=1.2e-06
mX0_X1_M2 N_6_X0_X1_M2_d N_X0_X1_6_X0_X1_M2_g N_GROUND_X0_X1_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X1_M3 N_X0_X1_6_X0_X1_M3_d N_X0_7_X0_X1_M3_g N_VDD_X0_X1_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX0_X1_M4 N_VDD_X0_X1_M4_d N_5_X0_X1_M4_g N_X0_X1_6_X0_X1_M3_d N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX0_X1_M5 N_6_X0_X1_M5_d N_X0_X1_6_X0_X1_M5_g N_VDD_X0_X1_M4_d N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX1_X0_M0 X1_X0_7 N_OP_0_X1_X0_M0_g N_X1_X0_6_X1_X0_M0_s N_GROUND_X0_X0_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX1_X0_M1 N_GROUND_X1_X0_M1_d N_4_X1_X0_M1_g X1_X0_7 N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=1.2e-06
mX1_X0_M2 N_X1_7_X1_X0_M2_d N_X1_X0_6_X1_X0_M2_g N_GROUND_X1_X0_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X0_M3 N_X1_X0_6_X1_X0_M3_d N_OP_0_X1_X0_M3_g N_VDD_X1_X0_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX1_X0_M4 N_VDD_X1_X0_M4_d N_4_X1_X0_M4_g N_X1_X0_6_X1_X0_M3_d N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX1_X0_M5 N_X1_7_X1_X0_M5_d N_X1_X0_6_X1_X0_M5_g N_VDD_X1_X0_M4_d
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX1_X1_M0 X1_X1_7 N_X1_7_X1_X1_M0_g N_X1_X1_6_X1_X1_M0_s N_GROUND_X0_X0_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX1_X1_M1 N_GROUND_X1_X1_M1_d N_5_X1_X1_M1_g X1_X1_7 N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=1.2e-06
mX1_X1_M2 N_8_X1_X1_M2_d N_X1_X1_6_X1_X1_M2_g N_GROUND_X1_X1_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X1_M3 N_X1_X1_6_X1_X1_M3_d N_X1_7_X1_X1_M3_g N_VDD_X1_X1_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX1_X1_M4 N_VDD_X1_X1_M4_d N_5_X1_X1_M4_g N_X1_X1_6_X1_X1_M3_d N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX1_X1_M5 N_8_X1_X1_M5_d N_X1_X1_6_X1_X1_M5_g N_VDD_X1_X1_M4_d N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX2_X0_M0 X2_X0_7 N_3_X2_X0_M0_g N_X2_X0_6_X2_X0_M0_s N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=1.2e-06
mX2_X0_M1 N_GROUND_X2_X0_M1_d N_OP_1_X2_X0_M1_g X2_X0_7 N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=1.2e-06
mX2_X0_M2 N_X2_7_X2_X0_M2_d N_X2_X0_6_X2_X0_M2_g N_GROUND_X2_X0_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X0_M3 N_X2_X0_6_X2_X0_M3_d N_3_X2_X0_M3_g N_VDD_X2_X0_M3_s N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX2_X0_M4 N_VDD_X2_X0_M4_d N_OP_1_X2_X0_M4_g N_X2_X0_6_X2_X0_M3_d
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX2_X0_M5 N_X2_7_X2_X0_M5_d N_X2_X0_6_X2_X0_M5_g N_VDD_X2_X0_M4_d
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX2_X1_M0 X2_X1_7 N_X2_7_X2_X1_M0_g N_X2_X1_6_X2_X1_M0_s N_GROUND_X0_X0_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX2_X1_M1 N_GROUND_X2_X1_M1_d N_5_X2_X1_M1_g X2_X1_7 N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=1.2e-06
mX2_X1_M2 N_13_X2_X1_M2_d N_X2_X1_6_X2_X1_M2_g N_GROUND_X2_X1_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X1_M3 N_X2_X1_6_X2_X1_M3_d N_X2_7_X2_X1_M3_g N_VDD_X2_X1_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX2_X1_M4 N_VDD_X2_X1_M4_d N_5_X2_X1_M4_g N_X2_X1_6_X2_X1_M3_d N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX2_X1_M5 N_13_X2_X1_M5_d N_X2_X1_6_X2_X1_M5_g N_VDD_X2_X1_M4_d N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX3_X0_M0 X3_X0_7 N_OP_0_X3_X0_M0_g N_X3_X0_6_X3_X0_M0_s N_GROUND_X0_X0_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX3_X0_M1 N_GROUND_X3_X0_M1_d N_OP_1_X3_X0_M1_g X3_X0_7 N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=1.2e-06
mX3_X0_M2 N_X3_7_X3_X0_M2_d N_X3_X0_6_X3_X0_M2_g N_GROUND_X3_X0_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X0_M3 N_X3_X0_6_X3_X0_M3_d N_OP_0_X3_X0_M3_g N_VDD_X3_X0_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX3_X0_M4 N_VDD_X3_X0_M4_d N_OP_1_X3_X0_M4_g N_X3_X0_6_X3_X0_M3_d
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX3_X0_M5 N_X3_7_X3_X0_M5_d N_X3_X0_6_X3_X0_M5_g N_VDD_X3_X0_M4_d
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX3_X1_M0 X3_X1_7 N_X3_7_X3_X1_M0_g N_X3_X1_6_X3_X1_M0_s N_GROUND_X0_X0_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX3_X1_M1 N_GROUND_X3_X1_M1_d N_5_X3_X1_M1_g X3_X1_7 N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=1.2e-06
mX3_X1_M2 N_15_X3_X1_M2_d N_X3_X1_6_X3_X1_M2_g N_GROUND_X3_X1_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X1_M3 N_X3_X1_6_X3_X1_M3_d N_X3_7_X3_X1_M3_g N_VDD_X3_X1_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX3_X1_M4 N_VDD_X3_X1_M4_d N_5_X3_X1_M4_g N_X3_X1_6_X3_X1_M3_d N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX3_X1_M5 N_15_X3_X1_M5_d N_X3_X1_6_X3_X1_M5_g N_VDD_X3_X1_M4_d N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX4_X0_M0 X4_X0_7 N_3_X4_X0_M0_g N_X4_X0_6_X4_X0_M0_s N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=1.2e-06
mX4_X0_M1 N_GROUND_X4_X0_M1_d N_4_X4_X0_M1_g X4_X0_7 N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=1.2e-06
mX4_X0_M2 N_X4_7_X4_X0_M2_d N_X4_X0_6_X4_X0_M2_g N_GROUND_X4_X0_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_M3 N_X4_X0_6_X4_X0_M3_d N_3_X4_X0_M3_g N_VDD_X4_X0_M3_s N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX4_X0_M4 N_VDD_X4_X0_M4_d N_4_X4_X0_M4_g N_X4_X0_6_X4_X0_M3_d N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX4_X0_M5 N_X4_7_X4_X0_M5_d N_X4_X0_6_X4_X0_M5_g N_VDD_X4_X0_M4_d
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_M0 X4_X1_7 N_X4_7_X4_X1_M0_g N_X4_X1_6_X4_X1_M0_s N_GROUND_X0_X0_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX4_X1_M1 N_GROUND_X4_X1_M1_d N_OP_2_X4_X1_M1_g X4_X1_7 N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=1.2e-06
mX4_X1_M2 N_18_X4_X1_M2_d N_X4_X1_6_X4_X1_M2_g N_GROUND_X4_X1_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_M3 N_X4_X1_6_X4_X1_M3_d N_X4_7_X4_X1_M3_g N_VDD_X4_X1_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_M4 N_VDD_X4_X1_M4_d N_OP_2_X4_X1_M4_g N_X4_X1_6_X4_X1_M3_d
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_M5 N_18_X4_X1_M5_d N_X4_X1_6_X4_X1_M5_g N_VDD_X4_X1_M4_d N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX5_X0_M0 X5_X0_7 N_OP_0_X5_X0_M0_g N_X5_X0_6_X5_X0_M0_s N_GROUND_X0_X0_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX5_X0_M1 N_GROUND_X5_X0_M1_d N_4_X5_X0_M1_g X5_X0_7 N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=1.2e-06
mX5_X0_M2 N_X5_7_X5_X0_M2_d N_X5_X0_6_X5_X0_M2_g N_GROUND_X5_X0_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_M3 N_X5_X0_6_X5_X0_M3_d N_OP_0_X5_X0_M3_g N_VDD_X5_X0_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_M4 N_VDD_X5_X0_M4_d N_4_X5_X0_M4_g N_X5_X0_6_X5_X0_M3_d N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX5_X0_M5 N_X5_7_X5_X0_M5_d N_X5_X0_6_X5_X0_M5_g N_VDD_X5_X0_M4_d
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_M0 X5_X1_7 N_X5_7_X5_X1_M0_g N_X5_X1_6_X5_X1_M0_s N_GROUND_X0_X0_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX5_X1_M1 N_GROUND_X5_X1_M1_d N_OP_2_X5_X1_M1_g X5_X1_7 N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=1.2e-06
mX5_X1_M2 N_10_X5_X1_M2_d N_X5_X1_6_X5_X1_M2_g N_GROUND_X5_X1_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_M3 N_X5_X1_6_X5_X1_M3_d N_X5_7_X5_X1_M3_g N_VDD_X5_X1_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_M4 N_VDD_X5_X1_M4_d N_OP_2_X5_X1_M4_g N_X5_X1_6_X5_X1_M3_d
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_M5 N_10_X5_X1_M5_d N_X5_X1_6_X5_X1_M5_g N_VDD_X5_X1_M4_d N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX6_X0_M0 X6_X0_7 N_3_X6_X0_M0_g N_X6_X0_6_X6_X0_M0_s N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=1.2e-06
mX6_X0_M1 N_GROUND_X6_X0_M1_d N_OP_1_X6_X0_M1_g X6_X0_7 N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=1.2e-06
mX6_X0_M2 N_X6_7_X6_X0_M2_d N_X6_X0_6_X6_X0_M2_g N_GROUND_X6_X0_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_M3 N_X6_X0_6_X6_X0_M3_d N_3_X6_X0_M3_g N_VDD_X6_X0_M3_s N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX6_X0_M4 N_VDD_X6_X0_M4_d N_OP_1_X6_X0_M4_g N_X6_X0_6_X6_X0_M3_d
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_M5 N_X6_7_X6_X0_M5_d N_X6_X0_6_X6_X0_M5_g N_VDD_X6_X0_M4_d
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_M0 X6_X1_7 N_X6_7_X6_X1_M0_g N_X6_X1_6_X6_X1_M0_s N_GROUND_X0_X0_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX6_X1_M1 N_GROUND_X6_X1_M1_d N_OP_2_X6_X1_M1_g X6_X1_7 N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=1.2e-06
mX6_X1_M2 N_PC_SRC_X6_X1_M2_d N_X6_X1_6_X6_X1_M2_g N_GROUND_X6_X1_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_M3 N_X6_X1_6_X6_X1_M3_d N_X6_7_X6_X1_M3_g N_VDD_X6_X1_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_M4 N_VDD_X6_X1_M4_d N_OP_2_X6_X1_M4_g N_X6_X1_6_X6_X1_M3_d
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_M5 N_PC_SRC_X6_X1_M5_d N_X6_X1_6_X6_X1_M5_g N_VDD_X6_X1_M4_d
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_M0 N_X7_6_X7_M0_d N_10_X7_M0_g N_GROUND_X7_M0_s N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX7_M1 N_GROUND_X7_M1_d N_12_X7_M1_g N_X7_6_X7_M0_d N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX7_M2 N_REG_WRITE_X7_M2_d N_X7_6_X7_M2_g N_GROUND_X7_M1_d N_GROUND_X0_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX7_M3 N_VDD_X7_M3_d N_X7_6_X7_M3_g N_REG_WRITE_X7_M3_s N_VDD_X0_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX7_M4 X7_7 N_12_X7_M4_g N_VDD_X7_M3_d N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX7_M5 N_X7_6_X7_M5_d N_10_X7_M5_g X7_7 N_VDD_X0_X0_M3_b PMOS L=1.3e-07
+ W=2.7e-06
mX8_M0 N_X8_6_X8_M0_d N_10_X8_M0_g N_GROUND_X8_M0_s N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX8_M1 N_GROUND_X8_M1_d N_16_X8_M1_g N_X8_6_X8_M0_d N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX8_M2 N_ALU_OP_1_X8_M2_d N_X8_6_X8_M2_g N_GROUND_X8_M1_d N_GROUND_X0_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX8_M3 N_VDD_X8_M3_d N_X8_6_X8_M3_g N_ALU_OP_1_X8_M3_s N_VDD_X0_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX8_M4 X8_7 N_16_X8_M4_g N_VDD_X8_M3_d N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX8_M5 N_X8_6_X8_M5_d N_10_X8_M5_g X8_7 N_VDD_X0_X0_M3_b PMOS L=1.3e-07
+ W=2.7e-06
mX9_M0 N_X9_6_X9_M0_d N_PC_SRC_X9_M0_g N_GROUND_X9_M0_s N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX9_M1 N_GROUND_X9_M1_d N_21_X9_M1_g N_X9_6_X9_M0_d N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX9_M2 N_ALU_OP_0_X9_M2_d N_X9_6_X9_M2_g N_GROUND_X9_M1_d N_GROUND_X0_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX9_M3 N_VDD_X9_M3_d N_X9_6_X9_M3_g N_ALU_OP_0_X9_M3_s N_VDD_X0_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX9_M4 X9_7 N_21_X9_M4_g N_VDD_X9_M3_d N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_M5 N_X9_6_X9_M5_d N_PC_SRC_X9_M5_g X9_7 N_VDD_X0_X0_M3_b PMOS L=1.3e-07
+ W=2.7e-06
mX10_X0_M0 N_X10_X0_6_X10_X0_M0_d N_8_X10_X0_M0_g N_GROUND_X10_X0_M0_s
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX10_X0_M1 N_GROUND_X10_X0_M1_d N_6_X10_X0_M1_g N_X10_X0_6_X10_X0_M0_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX10_X0_M2 N_X10_7_X10_X0_M2_d N_X10_X0_6_X10_X0_M2_g N_GROUND_X10_X0_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX10_X0_M3 N_VDD_X10_X0_M3_d N_X10_X0_6_X10_X0_M3_g N_X10_7_X10_X0_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX10_X0_M4 X10_X0_7 N_6_X10_X0_M4_g N_VDD_X10_X0_M3_d N_VDD_X0_X0_M3_b PMOS
+ L=1.3e-07 W=2.7e-06
mX10_X0_M5 N_X10_X0_6_X10_X0_M5_d N_8_X10_X0_M5_g X10_X0_7 N_VDD_X0_X0_M3_b PMOS
+ L=1.3e-07 W=2.7e-06
mX10_X1_M0 N_X10_X1_6_X10_X1_M0_d N_13_X10_X1_M0_g N_GROUND_X10_X1_M0_s
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX10_X1_M1 N_GROUND_X10_X1_M1_d N_X10_7_X10_X1_M1_g N_X10_X1_6_X10_X1_M0_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX10_X1_M2 N_22_X10_X1_M2_d N_X10_X1_6_X10_X1_M2_g N_GROUND_X10_X1_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX10_X1_M3 N_VDD_X10_X1_M3_d N_X10_X1_6_X10_X1_M3_g N_22_X10_X1_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX10_X1_M4 X10_X1_7 N_X10_7_X10_X1_M4_g N_VDD_X10_X1_M3_d N_VDD_X0_X0_M3_b PMOS
+ L=1.3e-07 W=2.7e-06
mX10_X1_M5 N_X10_X1_6_X10_X1_M5_d N_13_X10_X1_M5_g X10_X1_7 N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=2.7e-06
mX11_X0_M0 N_X11_X0_6_X11_X0_M0_d N_15_X11_X0_M0_g N_GROUND_X11_X0_M0_s
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX11_X0_M1 N_GROUND_X11_X0_M1_d N_22_X11_X0_M1_g N_X11_X0_6_X11_X0_M0_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX11_X0_M2 N_X11_7_X11_X0_M2_d N_X11_X0_6_X11_X0_M2_g N_GROUND_X11_X0_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX11_X0_M3 N_VDD_X11_X0_M3_d N_X11_X0_6_X11_X0_M3_g N_X11_7_X11_X0_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX11_X0_M4 X11_X0_7 N_22_X11_X0_M4_g N_VDD_X11_X0_M3_d N_VDD_X0_X0_M3_b PMOS
+ L=1.3e-07 W=2.7e-06
mX11_X0_M5 N_X11_X0_6_X11_X0_M5_d N_15_X11_X0_M5_g X11_X0_7 N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=2.7e-06
mX11_X1_M0 N_X11_X1_6_X11_X1_M0_d N_18_X11_X1_M0_g N_GROUND_X11_X1_M0_s
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX11_X1_M1 N_GROUND_X11_X1_M1_d N_X11_7_X11_X1_M1_g N_X11_X1_6_X11_X1_M0_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX11_X1_M2 N_12_X11_X1_M2_d N_X11_X1_6_X11_X1_M2_g N_GROUND_X11_X1_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX11_X1_M3 N_VDD_X11_X1_M3_d N_X11_X1_6_X11_X1_M3_g N_12_X11_X1_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX11_X1_M4 X11_X1_7 N_X11_7_X11_X1_M4_g N_VDD_X11_X1_M3_d N_VDD_X0_X0_M3_b PMOS
+ L=1.3e-07 W=2.7e-06
mX11_X1_M5 N_X11_X1_6_X11_X1_M5_d N_18_X11_X1_M5_g X11_X1_7 N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=2.7e-06
mX12_X0_M0 N_X12_X0_6_X12_X0_M0_d N_15_X12_X0_M0_g N_GROUND_X12_X0_M0_s
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX12_X0_M1 N_GROUND_X12_X0_M1_d N_13_X12_X0_M1_g N_X12_X0_6_X12_X0_M0_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX12_X0_M2 N_X12_7_X12_X0_M2_d N_X12_X0_6_X12_X0_M2_g N_GROUND_X12_X0_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX12_X0_M3 N_VDD_X12_X0_M3_d N_X12_X0_6_X12_X0_M3_g N_X12_7_X12_X0_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX12_X0_M4 X12_X0_7 N_13_X12_X0_M4_g N_VDD_X12_X0_M3_d N_VDD_X0_X0_M3_b PMOS
+ L=1.3e-07 W=2.7e-06
mX12_X0_M5 N_X12_X0_6_X12_X0_M5_d N_15_X12_X0_M5_g X12_X0_7 N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=2.7e-06
mX12_X1_M0 N_X12_X1_6_X12_X1_M0_d N_18_X12_X1_M0_g N_GROUND_X12_X1_M0_s
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX12_X1_M1 N_GROUND_X12_X1_M1_d N_X12_7_X12_X1_M1_g N_X12_X1_6_X12_X1_M0_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX12_X1_M2 N_16_X12_X1_M2_d N_X12_X1_6_X12_X1_M2_g N_GROUND_X12_X1_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX12_X1_M3 N_VDD_X12_X1_M3_d N_X12_X1_6_X12_X1_M3_g N_16_X12_X1_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX12_X1_M4 X12_X1_7 N_X12_7_X12_X1_M4_g N_VDD_X12_X1_M3_d N_VDD_X0_X0_M3_b PMOS
+ L=1.3e-07 W=2.7e-06
mX12_X1_M5 N_X12_X1_6_X12_X1_M5_d N_18_X12_X1_M5_g X12_X1_7 N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=2.7e-06
mX13_X0_M0 N_X13_X0_6_X13_X0_M0_d N_10_X13_X0_M0_g N_GROUND_X13_X0_M0_s
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX13_X0_M1 N_GROUND_X13_X0_M1_d N_15_X13_X0_M1_g N_X13_X0_6_X13_X0_M0_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX13_X0_M2 N_X13_7_X13_X0_M2_d N_X13_X0_6_X13_X0_M2_g N_GROUND_X13_X0_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX13_X0_M3 N_VDD_X13_X0_M3_d N_X13_X0_6_X13_X0_M3_g N_X13_7_X13_X0_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX13_X0_M4 X13_X0_7 N_15_X13_X0_M4_g N_VDD_X13_X0_M3_d N_VDD_X0_X0_M3_b PMOS
+ L=1.3e-07 W=2.7e-06
mX13_X0_M5 N_X13_X0_6_X13_X0_M5_d N_10_X13_X0_M5_g X13_X0_7 N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=2.7e-06
mX13_X1_M0 N_X13_X1_6_X13_X1_M0_d N_PC_SRC_X13_X1_M0_g N_GROUND_X13_X1_M0_s
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX13_X1_M1 N_GROUND_X13_X1_M1_d N_X13_7_X13_X1_M1_g N_X13_X1_6_X13_X1_M0_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX13_X1_M2 N_ALU_SRC_X13_X1_M2_d N_X13_X1_6_X13_X1_M2_g N_GROUND_X13_X1_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX13_X1_M3 N_VDD_X13_X1_M3_d N_X13_X1_6_X13_X1_M3_g N_ALU_SRC_X13_X1_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX13_X1_M4 X13_X1_7 N_X13_7_X13_X1_M4_g N_VDD_X13_X1_M3_d N_VDD_X0_X0_M3_b PMOS
+ L=1.3e-07 W=2.7e-06
mX13_X1_M5 N_X13_X1_6_X13_X1_M5_d N_PC_SRC_X13_X1_M5_g X13_X1_7 N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=2.7e-06
mX14_X0_M0 N_X14_X0_6_X14_X0_M0_d N_18_X14_X0_M0_g N_GROUND_X14_X0_M0_s
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX14_X0_M1 N_GROUND_X14_X0_M1_d N_8_X14_X0_M1_g N_X14_X0_6_X14_X0_M0_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX14_X0_M2 N_X14_7_X14_X0_M2_d N_X14_X0_6_X14_X0_M2_g N_GROUND_X14_X0_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX14_X0_M3 N_VDD_X14_X0_M3_d N_X14_X0_6_X14_X0_M3_g N_X14_7_X14_X0_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX14_X0_M4 X14_X0_7 N_8_X14_X0_M4_g N_VDD_X14_X0_M3_d N_VDD_X0_X0_M3_b PMOS
+ L=1.3e-07 W=2.7e-06
mX14_X0_M5 N_X14_X0_6_X14_X0_M5_d N_18_X14_X0_M5_g X14_X0_7 N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=2.7e-06
mX14_X1_M0 N_X14_X1_6_X14_X1_M0_d N_10_X14_X1_M0_g N_GROUND_X14_X1_M0_s
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX14_X1_M1 N_GROUND_X14_X1_M1_d N_X14_7_X14_X1_M1_g N_X14_X1_6_X14_X1_M0_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX14_X1_M2 N_21_X14_X1_M2_d N_X14_X1_6_X14_X1_M2_g N_GROUND_X14_X1_M1_d
+ N_GROUND_X0_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX14_X1_M3 N_VDD_X14_X1_M3_d N_X14_X1_6_X14_X1_M3_g N_21_X14_X1_M3_s
+ N_VDD_X0_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX14_X1_M4 X14_X1_7 N_X14_7_X14_X1_M4_g N_VDD_X14_X1_M3_d N_VDD_X0_X0_M3_b PMOS
+ L=1.3e-07 W=2.7e-06
mX14_X1_M5 N_X14_X1_6_X14_X1_M5_d N_10_X14_X1_M5_g X14_X1_7 N_VDD_X0_X0_M3_b
+ PMOS L=1.3e-07 W=2.7e-06
mX15_M0 N_3_X15_M0_d N_OP_0_X15_M0_g N_GROUND_X15_M0_s N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX15_M1 N_3_X15_M1_d N_OP_0_X15_M1_g N_VDD_X15_M1_s N_VDD_X0_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX16_M0 N_4_X16_M0_d N_OP_1_X16_M0_g N_GROUND_X16_M0_s N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX16_M1 N_4_X16_M1_d N_OP_1_X16_M1_g N_VDD_X16_M1_s N_VDD_X0_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX17_M0 N_5_X17_M0_d N_OP_2_X17_M0_g N_GROUND_X17_M0_s N_GROUND_X0_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX17_M1 N_5_X17_M1_d N_OP_2_X17_M1_g N_VDD_X17_M1_s N_VDD_X0_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
*
.include "control.pex.netlist.CONTROL.pxi"
*
.End
*
*
