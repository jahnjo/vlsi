*  Spice netlist imm_mux.pex.netlist transformed for AMS-Sim
*    additions

.LIB $MGC_DESIGN_KIT/models/lib.eldo TT

Vvdd VDD 0 2.5
Vgnd ground 0 0

*  Here begins the original spice file

* File: imm_mux.pex.netlist
* Created: Thu Apr 18 14:05:04 2019
* Program "Calibre xRC"
* Version "v2012.2_36.25"
*
.global VDD VSS
.include "imm_mux.pex.netlist.pex"
*
* IMM_1	IMM_1
* BUSW_RESULT_1	BUSW_RESULT_1
* RESULT_1	RESULT_1
* IMM_0	IMM_0
* BUSW_RESULT_0	BUSW_RESULT_0
* INPUT_SELECT	INPUT_SELECT
* RESULT_0	RESULT_0
* IMM_2	IMM_2
* BUSW_RESULT_2	BUSW_RESULT_2
* RESULT_2	RESULT_2
* IMM_3	IMM_3
* BUSW_RESULT_3	BUSW_RESULT_3
* RESULT_3	RESULT_3
* GROUND	GROUND
* VDD	VDD
mX0_M0 N_BUSW_RESULT_3_X0_M0_d N_X0_7_X0_M0_g N_RESULT_3_X0_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX0_M1 N_IMM_3_X0_M1_d N_INPUT_SELECT_X0_M1_g N_BUSW_RESULT_3_X0_M0_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX0_M2 N_X0_7_X0_M2_d N_INPUT_SELECT_X0_M2_g N_GROUND_X0_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX0_M3 N_BUSW_RESULT_3_X0_M3_d N_INPUT_SELECT_X0_M3_g N_RESULT_3_X0_M3_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX0_M4 N_IMM_3_X0_M4_d N_X0_7_X0_M4_g N_BUSW_RESULT_3_X0_M3_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX0_M5 N_X0_7_X0_M5_d N_INPUT_SELECT_X0_M5_g N_VDD_X0_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX1_M0 N_BUSW_RESULT_2_X1_M0_d N_X1_7_X1_M0_g N_RESULT_2_X1_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX1_M1 N_IMM_2_X1_M1_d N_INPUT_SELECT_X1_M1_g N_BUSW_RESULT_2_X1_M0_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX1_M2 N_X1_7_X1_M2_d N_INPUT_SELECT_X1_M2_g N_GROUND_X1_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX1_M3 N_BUSW_RESULT_2_X1_M3_d N_INPUT_SELECT_X1_M3_g N_RESULT_2_X1_M3_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX1_M4 N_IMM_2_X1_M4_d N_X1_7_X1_M4_g N_BUSW_RESULT_2_X1_M3_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX1_M5 N_X1_7_X1_M5_d N_INPUT_SELECT_X1_M5_g N_VDD_X1_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX2_M0 N_BUSW_RESULT_0_X2_M0_d N_X2_7_X2_M0_g N_RESULT_0_X2_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX2_M1 N_IMM_0_X2_M1_d N_INPUT_SELECT_X2_M1_g N_BUSW_RESULT_0_X2_M0_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX2_M2 N_X2_7_X2_M2_d N_INPUT_SELECT_X2_M2_g N_GROUND_X2_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX2_M3 N_BUSW_RESULT_0_X2_M3_d N_INPUT_SELECT_X2_M3_g N_RESULT_0_X2_M3_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX2_M4 N_IMM_0_X2_M4_d N_X2_7_X2_M4_g N_BUSW_RESULT_0_X2_M3_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX2_M5 N_X2_7_X2_M5_d N_INPUT_SELECT_X2_M5_g N_VDD_X2_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX3_M0 N_BUSW_RESULT_1_X3_M0_d N_X3_7_X3_M0_g N_RESULT_1_X3_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX3_M1 N_IMM_1_X3_M1_d N_INPUT_SELECT_X3_M1_g N_BUSW_RESULT_1_X3_M0_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX3_M2 N_X3_7_X3_M2_d N_INPUT_SELECT_X3_M2_g N_GROUND_X3_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX3_M3 N_BUSW_RESULT_1_X3_M3_d N_INPUT_SELECT_X3_M3_g N_RESULT_1_X3_M3_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX3_M4 N_IMM_1_X3_M4_d N_X3_7_X3_M4_g N_BUSW_RESULT_1_X3_M3_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX3_M5 N_X3_7_X3_M5_d N_INPUT_SELECT_X3_M5_g N_VDD_X3_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
*
.include "imm_mux.pex.netlist.IMM_MUX.pxi"
*
.End
*
*
