*  Spice netlist reg.pex.netlist transformed for AMS-Sim
*    additions

.LIB $MGC_DESIGN_KIT/models/lib.eldo TT

Vvdd VDD 0 2.5
Vgnd ground 0 0

*  Here begins the original spice file

* File: reg.pex.netlist
* Created: Thu Apr 18 14:09:30 2019
* Program "Calibre xRC"
* Version "v2012.2_36.25"
*
.global VDD VSS
.include "reg.pex.netlist.pex"
*
* CLK	CLK
* RS2	RS2
* BUSB	BUSB
* RS1	RS1
* RS0	RS0
* BUSW	BUSW
* RT2	RT2
* BUSA	BUSA
* RT1	RT1
* RT0	RT0
* REG_W	REG_W
* DEC7	DEC7
* DEC6	DEC6
* DEC5	DEC5
* DEC4	DEC4
* DEC3	DEC3
* DEC2	DEC2
* DEC1	DEC1
* DEC0	DEC0
* GROUND	GROUND
* VDD	VDD
mX0_X0_M0 N_GROUND_X0_X0_M0_d N_X0_X0_11_X0_X0_M0_g N_20_X0_X0_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X0_M1 N_X0_X0_7_X0_X0_M1_d N_X0_X0_10_X0_X0_M1_g N_GROUND_X0_X0_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X0_M2 X0_X0_8 N_X0_X0_15_X0_X0_M2_g N_X0_X0_7_X0_X0_M1_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X0_M3 N_GROUND_X0_X0_M3_d N_X0_X0_16_X0_X0_M3_g X0_X0_8
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X0_M4 X0_X0_9 N_X0_X0_14_X0_X0_M4_g N_GROUND_X0_X0_M3_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X0_M5 N_X0_X0_10_X0_X0_M5_d N_X0_X0_15_X0_X0_M5_g X0_X0_9
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X0_M6 N_GROUND_X0_X0_M6_d N_X0_X0_7_X0_X0_M6_g N_X0_X0_10_X0_X0_M5_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X0_M7 N_X0_X0_11_X0_X0_M7_d N_20_X0_X0_M7_g N_GROUND_X0_X0_M6_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X0_M8 X0_X0_12 N_CLK_X0_X0_M8_g N_X0_X0_11_X0_X0_M8_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X0_M9 N_GROUND_X0_X0_M9_d N_X0_X0_10_X0_X0_M9_g X0_X0_12
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X0_M10 X0_X0_13 N_X0_X0_7_X0_X0_M10_g N_GROUND_X0_X0_M9_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X0_M11 N_20_X0_X0_M11_d N_CLK_X0_X0_M11_g X0_X0_13 N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX0_X0_M12 N_GROUND_X0_X0_M12_d N_X0_X0_16_X0_X0_M12_g N_X0_X0_14_X0_X0_M12_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X0_M13 N_X0_X0_15_X0_X0_M13_d N_CLK_X0_X0_M13_g N_GROUND_X0_X0_M12_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X0_M14 N_VDD_X0_X0_M14_d N_X0_X0_16_X0_X0_M14_g N_X0_X0_14_X0_X0_M14_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX0_X0_M15 N_X0_X0_15_X0_X0_M15_d N_CLK_X0_X0_M15_g N_VDD_X0_X0_M14_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX0_X0_M16 N_VDD_X0_X0_M16_d N_X0_X0_7_X0_X0_M16_g N_X0_X0_10_X0_X0_M16_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX0_X0_M17 N_X0_X0_7_X0_X0_M17_d N_X0_X0_10_X0_X0_M17_g N_VDD_X0_X0_M16_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX0_X0_M18 N_VDD_X0_X0_M18_d N_X0_X0_11_X0_X0_M18_g N_20_X0_X0_M18_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX0_X0_M19 N_X0_X0_11_X0_X0_M19_d N_20_X0_X0_M19_g N_VDD_X0_X0_M18_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX0_X0_X20_M0 N_X0_X0_16_X0_X0_X20_M0_d N_X0_X0_X20_7_X0_X0_X20_M0_g
+ N_20_X0_X0_X20_M0_s N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X0_X20_M1 N_BUSW_X0_X0_X20_M1_d N_4_X0_X0_X20_M1_g N_X0_X0_16_X0_X0_X20_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X0_X20_M2 N_X0_X0_X20_7_X0_X0_X20_M2_d N_4_X0_X0_X20_M2_g
+ N_GROUND_X0_X0_X20_M2_s N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X0_X20_M3 N_X0_X0_16_X0_X0_X20_M3_d N_4_X0_X0_X20_M3_g N_20_X0_X0_X20_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX0_X0_X20_M4 N_BUSW_X0_X0_X20_M4_d N_X0_X0_X20_7_X0_X0_X20_M4_g
+ N_X0_X0_16_X0_X0_X20_M3_d N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX0_X0_X20_M5 N_X0_X0_X20_7_X0_X0_X20_M5_d N_4_X0_X0_X20_M5_g
+ N_VDD_X0_X0_X20_M5_s N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX0_X1_M0 N_GROUND_X0_X1_M0_d N_X0_X1_11_X0_X1_M0_g N_21_X0_X1_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X1_M1 N_X0_X1_7_X0_X1_M1_d N_X0_X1_10_X0_X1_M1_g N_GROUND_X0_X1_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X1_M2 X0_X1_8 N_X0_X1_15_X0_X1_M2_g N_X0_X1_7_X0_X1_M1_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X1_M3 N_GROUND_X0_X1_M3_d N_X0_X1_16_X0_X1_M3_g X0_X1_8
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X1_M4 X0_X1_9 N_X0_X1_14_X0_X1_M4_g N_GROUND_X0_X1_M3_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X1_M5 N_X0_X1_10_X0_X1_M5_d N_X0_X1_15_X0_X1_M5_g X0_X1_9
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X1_M6 N_GROUND_X0_X1_M6_d N_X0_X1_7_X0_X1_M6_g N_X0_X1_10_X0_X1_M5_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X1_M7 N_X0_X1_11_X0_X1_M7_d N_21_X0_X1_M7_g N_GROUND_X0_X1_M6_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X1_M8 X0_X1_12 N_CLK_X0_X1_M8_g N_X0_X1_11_X0_X1_M8_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X1_M9 N_GROUND_X0_X1_M9_d N_X0_X1_10_X0_X1_M9_g X0_X1_12
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X1_M10 X0_X1_13 N_X0_X1_7_X0_X1_M10_g N_GROUND_X0_X1_M9_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X1_M11 N_21_X0_X1_M11_d N_CLK_X0_X1_M11_g X0_X1_13 N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX0_X1_M12 N_GROUND_X0_X1_M12_d N_X0_X1_16_X0_X1_M12_g N_X0_X1_14_X0_X1_M12_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X1_M13 N_X0_X1_15_X0_X1_M13_d N_CLK_X0_X1_M13_g N_GROUND_X0_X1_M12_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X1_M14 N_VDD_X0_X1_M14_d N_X0_X1_16_X0_X1_M14_g N_X0_X1_14_X0_X1_M14_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX0_X1_M15 N_X0_X1_15_X0_X1_M15_d N_CLK_X0_X1_M15_g N_VDD_X0_X1_M14_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX0_X1_M16 N_VDD_X0_X1_M16_d N_X0_X1_7_X0_X1_M16_g N_X0_X1_10_X0_X1_M16_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX0_X1_M17 N_X0_X1_7_X0_X1_M17_d N_X0_X1_10_X0_X1_M17_g N_VDD_X0_X1_M16_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX0_X1_M18 N_VDD_X0_X1_M18_d N_X0_X1_11_X0_X1_M18_g N_21_X0_X1_M18_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX0_X1_M19 N_X0_X1_11_X0_X1_M19_d N_21_X0_X1_M19_g N_VDD_X0_X1_M18_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX0_X1_X20_M0 N_X0_X1_16_X0_X1_X20_M0_d N_X0_X1_X20_7_X0_X1_X20_M0_g
+ N_21_X0_X1_X20_M0_s N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X1_X20_M1 N_BUSW_X0_X1_X20_M1_d N_6_X0_X1_X20_M1_g N_X0_X1_16_X0_X1_X20_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X1_X20_M2 N_X0_X1_X20_7_X0_X1_X20_M2_d N_6_X0_X1_X20_M2_g
+ N_GROUND_X0_X1_X20_M2_s N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX0_X1_X20_M3 N_X0_X1_16_X0_X1_X20_M3_d N_6_X0_X1_X20_M3_g N_21_X0_X1_X20_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX0_X1_X20_M4 N_BUSW_X0_X1_X20_M4_d N_X0_X1_X20_7_X0_X1_X20_M4_g
+ N_X0_X1_16_X0_X1_X20_M3_d N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX0_X1_X20_M5 N_X0_X1_X20_7_X0_X1_X20_M5_d N_6_X0_X1_X20_M5_g
+ N_VDD_X0_X1_X20_M5_s N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX1_X0_M0 N_GROUND_X1_X0_M0_d N_X1_X0_11_X1_X0_M0_g N_22_X1_X0_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X0_M1 N_X1_X0_7_X1_X0_M1_d N_X1_X0_10_X1_X0_M1_g N_GROUND_X1_X0_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X0_M2 X1_X0_8 N_X1_X0_15_X1_X0_M2_g N_X1_X0_7_X1_X0_M1_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X0_M3 N_GROUND_X1_X0_M3_d N_X1_X0_16_X1_X0_M3_g X1_X0_8
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X0_M4 X1_X0_9 N_X1_X0_14_X1_X0_M4_g N_GROUND_X1_X0_M3_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X0_M5 N_X1_X0_10_X1_X0_M5_d N_X1_X0_15_X1_X0_M5_g X1_X0_9
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X0_M6 N_GROUND_X1_X0_M6_d N_X1_X0_7_X1_X0_M6_g N_X1_X0_10_X1_X0_M5_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X0_M7 N_X1_X0_11_X1_X0_M7_d N_22_X1_X0_M7_g N_GROUND_X1_X0_M6_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X0_M8 X1_X0_12 N_CLK_X1_X0_M8_g N_X1_X0_11_X1_X0_M8_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X0_M9 N_GROUND_X1_X0_M9_d N_X1_X0_10_X1_X0_M9_g X1_X0_12
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X0_M10 X1_X0_13 N_X1_X0_7_X1_X0_M10_g N_GROUND_X1_X0_M9_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X0_M11 N_22_X1_X0_M11_d N_CLK_X1_X0_M11_g X1_X0_13 N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX1_X0_M12 N_GROUND_X1_X0_M12_d N_X1_X0_16_X1_X0_M12_g N_X1_X0_14_X1_X0_M12_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X0_M13 N_X1_X0_15_X1_X0_M13_d N_CLK_X1_X0_M13_g N_GROUND_X1_X0_M12_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X0_M14 N_VDD_X1_X0_M14_d N_X1_X0_16_X1_X0_M14_g N_X1_X0_14_X1_X0_M14_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX1_X0_M15 N_X1_X0_15_X1_X0_M15_d N_CLK_X1_X0_M15_g N_VDD_X1_X0_M14_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX1_X0_M16 N_VDD_X1_X0_M16_d N_X1_X0_7_X1_X0_M16_g N_X1_X0_10_X1_X0_M16_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX1_X0_M17 N_X1_X0_7_X1_X0_M17_d N_X1_X0_10_X1_X0_M17_g N_VDD_X1_X0_M16_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX1_X0_M18 N_VDD_X1_X0_M18_d N_X1_X0_11_X1_X0_M18_g N_22_X1_X0_M18_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX1_X0_M19 N_X1_X0_11_X1_X0_M19_d N_22_X1_X0_M19_g N_VDD_X1_X0_M18_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX1_X0_X20_M0 N_X1_X0_16_X1_X0_X20_M0_d N_X1_X0_X20_7_X1_X0_X20_M0_g
+ N_22_X1_X0_X20_M0_s N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X0_X20_M1 N_BUSW_X1_X0_X20_M1_d N_8_X1_X0_X20_M1_g N_X1_X0_16_X1_X0_X20_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X0_X20_M2 N_X1_X0_X20_7_X1_X0_X20_M2_d N_8_X1_X0_X20_M2_g
+ N_GROUND_X1_X0_X20_M2_s N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X0_X20_M3 N_X1_X0_16_X1_X0_X20_M3_d N_8_X1_X0_X20_M3_g N_22_X1_X0_X20_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX1_X0_X20_M4 N_BUSW_X1_X0_X20_M4_d N_X1_X0_X20_7_X1_X0_X20_M4_g
+ N_X1_X0_16_X1_X0_X20_M3_d N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX1_X0_X20_M5 N_X1_X0_X20_7_X1_X0_X20_M5_d N_8_X1_X0_X20_M5_g
+ N_VDD_X1_X0_X20_M5_s N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX1_X1_M0 N_GROUND_X1_X1_M0_d N_X1_X1_11_X1_X1_M0_g N_23_X1_X1_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X1_M1 N_X1_X1_7_X1_X1_M1_d N_X1_X1_10_X1_X1_M1_g N_GROUND_X1_X1_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X1_M2 X1_X1_8 N_X1_X1_15_X1_X1_M2_g N_X1_X1_7_X1_X1_M1_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X1_M3 N_GROUND_X1_X1_M3_d N_X1_X1_16_X1_X1_M3_g X1_X1_8
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X1_M4 X1_X1_9 N_X1_X1_14_X1_X1_M4_g N_GROUND_X1_X1_M3_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X1_M5 N_X1_X1_10_X1_X1_M5_d N_X1_X1_15_X1_X1_M5_g X1_X1_9
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X1_M6 N_GROUND_X1_X1_M6_d N_X1_X1_7_X1_X1_M6_g N_X1_X1_10_X1_X1_M5_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X1_M7 N_X1_X1_11_X1_X1_M7_d N_23_X1_X1_M7_g N_GROUND_X1_X1_M6_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X1_M8 X1_X1_12 N_CLK_X1_X1_M8_g N_X1_X1_11_X1_X1_M8_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X1_M9 N_GROUND_X1_X1_M9_d N_X1_X1_10_X1_X1_M9_g X1_X1_12
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X1_M10 X1_X1_13 N_X1_X1_7_X1_X1_M10_g N_GROUND_X1_X1_M9_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X1_M11 N_23_X1_X1_M11_d N_CLK_X1_X1_M11_g X1_X1_13 N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX1_X1_M12 N_GROUND_X1_X1_M12_d N_X1_X1_16_X1_X1_M12_g N_X1_X1_14_X1_X1_M12_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X1_M13 N_X1_X1_15_X1_X1_M13_d N_CLK_X1_X1_M13_g N_GROUND_X1_X1_M12_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X1_M14 N_VDD_X1_X1_M14_d N_X1_X1_16_X1_X1_M14_g N_X1_X1_14_X1_X1_M14_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX1_X1_M15 N_X1_X1_15_X1_X1_M15_d N_CLK_X1_X1_M15_g N_VDD_X1_X1_M14_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX1_X1_M16 N_VDD_X1_X1_M16_d N_X1_X1_7_X1_X1_M16_g N_X1_X1_10_X1_X1_M16_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX1_X1_M17 N_X1_X1_7_X1_X1_M17_d N_X1_X1_10_X1_X1_M17_g N_VDD_X1_X1_M16_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX1_X1_M18 N_VDD_X1_X1_M18_d N_X1_X1_11_X1_X1_M18_g N_23_X1_X1_M18_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX1_X1_M19 N_X1_X1_11_X1_X1_M19_d N_23_X1_X1_M19_g N_VDD_X1_X1_M18_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX1_X1_X20_M0 N_X1_X1_16_X1_X1_X20_M0_d N_X1_X1_X20_7_X1_X1_X20_M0_g
+ N_23_X1_X1_X20_M0_s N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X1_X20_M1 N_BUSW_X1_X1_X20_M1_d N_10_X1_X1_X20_M1_g
+ N_X1_X1_16_X1_X1_X20_M0_d N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X1_X20_M2 N_X1_X1_X20_7_X1_X1_X20_M2_d N_10_X1_X1_X20_M2_g
+ N_GROUND_X1_X1_X20_M2_s N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX1_X1_X20_M3 N_X1_X1_16_X1_X1_X20_M3_d N_10_X1_X1_X20_M3_g N_23_X1_X1_X20_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX1_X1_X20_M4 N_BUSW_X1_X1_X20_M4_d N_X1_X1_X20_7_X1_X1_X20_M4_g
+ N_X1_X1_16_X1_X1_X20_M3_d N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX1_X1_X20_M5 N_X1_X1_X20_7_X1_X1_X20_M5_d N_10_X1_X1_X20_M5_g
+ N_VDD_X1_X1_X20_M5_s N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX2_X0_M0 N_GROUND_X2_X0_M0_d N_X2_X0_11_X2_X0_M0_g N_24_X2_X0_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X0_M1 N_X2_X0_7_X2_X0_M1_d N_X2_X0_10_X2_X0_M1_g N_GROUND_X2_X0_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X0_M2 X2_X0_8 N_X2_X0_15_X2_X0_M2_g N_X2_X0_7_X2_X0_M1_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X0_M3 N_GROUND_X2_X0_M3_d N_X2_X0_16_X2_X0_M3_g X2_X0_8
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X0_M4 X2_X0_9 N_X2_X0_14_X2_X0_M4_g N_GROUND_X2_X0_M3_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X0_M5 N_X2_X0_10_X2_X0_M5_d N_X2_X0_15_X2_X0_M5_g X2_X0_9
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X0_M6 N_GROUND_X2_X0_M6_d N_X2_X0_7_X2_X0_M6_g N_X2_X0_10_X2_X0_M5_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X0_M7 N_X2_X0_11_X2_X0_M7_d N_24_X2_X0_M7_g N_GROUND_X2_X0_M6_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X0_M8 X2_X0_12 N_CLK_X2_X0_M8_g N_X2_X0_11_X2_X0_M8_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X0_M9 N_GROUND_X2_X0_M9_d N_X2_X0_10_X2_X0_M9_g X2_X0_12
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X0_M10 X2_X0_13 N_X2_X0_7_X2_X0_M10_g N_GROUND_X2_X0_M9_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X0_M11 N_24_X2_X0_M11_d N_CLK_X2_X0_M11_g X2_X0_13 N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX2_X0_M12 N_GROUND_X2_X0_M12_d N_X2_X0_16_X2_X0_M12_g N_X2_X0_14_X2_X0_M12_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X0_M13 N_X2_X0_15_X2_X0_M13_d N_CLK_X2_X0_M13_g N_GROUND_X2_X0_M12_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X0_M14 N_VDD_X2_X0_M14_d N_X2_X0_16_X2_X0_M14_g N_X2_X0_14_X2_X0_M14_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX2_X0_M15 N_X2_X0_15_X2_X0_M15_d N_CLK_X2_X0_M15_g N_VDD_X2_X0_M14_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX2_X0_M16 N_VDD_X2_X0_M16_d N_X2_X0_7_X2_X0_M16_g N_X2_X0_10_X2_X0_M16_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX2_X0_M17 N_X2_X0_7_X2_X0_M17_d N_X2_X0_10_X2_X0_M17_g N_VDD_X2_X0_M16_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX2_X0_M18 N_VDD_X2_X0_M18_d N_X2_X0_11_X2_X0_M18_g N_24_X2_X0_M18_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX2_X0_M19 N_X2_X0_11_X2_X0_M19_d N_24_X2_X0_M19_g N_VDD_X2_X0_M18_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX2_X0_X20_M0 N_X2_X0_16_X2_X0_X20_M0_d N_X2_X0_X20_7_X2_X0_X20_M0_g
+ N_24_X2_X0_X20_M0_s N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X0_X20_M1 N_BUSW_X2_X0_X20_M1_d N_12_X2_X0_X20_M1_g
+ N_X2_X0_16_X2_X0_X20_M0_d N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X0_X20_M2 N_X2_X0_X20_7_X2_X0_X20_M2_d N_12_X2_X0_X20_M2_g
+ N_GROUND_X2_X0_X20_M2_s N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X0_X20_M3 N_X2_X0_16_X2_X0_X20_M3_d N_12_X2_X0_X20_M3_g N_24_X2_X0_X20_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX2_X0_X20_M4 N_BUSW_X2_X0_X20_M4_d N_X2_X0_X20_7_X2_X0_X20_M4_g
+ N_X2_X0_16_X2_X0_X20_M3_d N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX2_X0_X20_M5 N_X2_X0_X20_7_X2_X0_X20_M5_d N_12_X2_X0_X20_M5_g
+ N_VDD_X2_X0_X20_M5_s N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX2_X1_M0 N_GROUND_X2_X1_M0_d N_X2_X1_11_X2_X1_M0_g N_26_X2_X1_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X1_M1 N_X2_X1_7_X2_X1_M1_d N_X2_X1_10_X2_X1_M1_g N_GROUND_X2_X1_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X1_M2 X2_X1_8 N_X2_X1_15_X2_X1_M2_g N_X2_X1_7_X2_X1_M1_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X1_M3 N_GROUND_X2_X1_M3_d N_X2_X1_16_X2_X1_M3_g X2_X1_8
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X1_M4 X2_X1_9 N_X2_X1_14_X2_X1_M4_g N_GROUND_X2_X1_M3_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X1_M5 N_X2_X1_10_X2_X1_M5_d N_X2_X1_15_X2_X1_M5_g X2_X1_9
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X1_M6 N_GROUND_X2_X1_M6_d N_X2_X1_7_X2_X1_M6_g N_X2_X1_10_X2_X1_M5_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X1_M7 N_X2_X1_11_X2_X1_M7_d N_26_X2_X1_M7_g N_GROUND_X2_X1_M6_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X1_M8 X2_X1_12 N_CLK_X2_X1_M8_g N_X2_X1_11_X2_X1_M8_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X1_M9 N_GROUND_X2_X1_M9_d N_X2_X1_10_X2_X1_M9_g X2_X1_12
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X1_M10 X2_X1_13 N_X2_X1_7_X2_X1_M10_g N_GROUND_X2_X1_M9_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X1_M11 N_26_X2_X1_M11_d N_CLK_X2_X1_M11_g X2_X1_13 N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX2_X1_M12 N_GROUND_X2_X1_M12_d N_X2_X1_16_X2_X1_M12_g N_X2_X1_14_X2_X1_M12_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X1_M13 N_X2_X1_15_X2_X1_M13_d N_CLK_X2_X1_M13_g N_GROUND_X2_X1_M12_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X1_M14 N_VDD_X2_X1_M14_d N_X2_X1_16_X2_X1_M14_g N_X2_X1_14_X2_X1_M14_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX2_X1_M15 N_X2_X1_15_X2_X1_M15_d N_CLK_X2_X1_M15_g N_VDD_X2_X1_M14_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX2_X1_M16 N_VDD_X2_X1_M16_d N_X2_X1_7_X2_X1_M16_g N_X2_X1_10_X2_X1_M16_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX2_X1_M17 N_X2_X1_7_X2_X1_M17_d N_X2_X1_10_X2_X1_M17_g N_VDD_X2_X1_M16_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX2_X1_M18 N_VDD_X2_X1_M18_d N_X2_X1_11_X2_X1_M18_g N_26_X2_X1_M18_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX2_X1_M19 N_X2_X1_11_X2_X1_M19_d N_26_X2_X1_M19_g N_VDD_X2_X1_M18_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX2_X1_X20_M0 N_X2_X1_16_X2_X1_X20_M0_d N_X2_X1_X20_7_X2_X1_X20_M0_g
+ N_26_X2_X1_X20_M0_s N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X1_X20_M1 N_BUSW_X2_X1_X20_M1_d N_14_X2_X1_X20_M1_g
+ N_X2_X1_16_X2_X1_X20_M0_d N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X1_X20_M2 N_X2_X1_X20_7_X2_X1_X20_M2_d N_14_X2_X1_X20_M2_g
+ N_GROUND_X2_X1_X20_M2_s N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX2_X1_X20_M3 N_X2_X1_16_X2_X1_X20_M3_d N_14_X2_X1_X20_M3_g N_26_X2_X1_X20_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX2_X1_X20_M4 N_BUSW_X2_X1_X20_M4_d N_X2_X1_X20_7_X2_X1_X20_M4_g
+ N_X2_X1_16_X2_X1_X20_M3_d N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX2_X1_X20_M5 N_X2_X1_X20_7_X2_X1_X20_M5_d N_14_X2_X1_X20_M5_g
+ N_VDD_X2_X1_X20_M5_s N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX3_X0_M0 N_GROUND_X3_X0_M0_d N_X3_X0_11_X3_X0_M0_g N_27_X3_X0_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X0_M1 N_X3_X0_7_X3_X0_M1_d N_X3_X0_10_X3_X0_M1_g N_GROUND_X3_X0_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X0_M2 X3_X0_8 N_X3_X0_15_X3_X0_M2_g N_X3_X0_7_X3_X0_M1_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X0_M3 N_GROUND_X3_X0_M3_d N_X3_X0_16_X3_X0_M3_g X3_X0_8
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X0_M4 X3_X0_9 N_X3_X0_14_X3_X0_M4_g N_GROUND_X3_X0_M3_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X0_M5 N_X3_X0_10_X3_X0_M5_d N_X3_X0_15_X3_X0_M5_g X3_X0_9
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X0_M6 N_GROUND_X3_X0_M6_d N_X3_X0_7_X3_X0_M6_g N_X3_X0_10_X3_X0_M5_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X0_M7 N_X3_X0_11_X3_X0_M7_d N_27_X3_X0_M7_g N_GROUND_X3_X0_M6_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X0_M8 X3_X0_12 N_CLK_X3_X0_M8_g N_X3_X0_11_X3_X0_M8_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X0_M9 N_GROUND_X3_X0_M9_d N_X3_X0_10_X3_X0_M9_g X3_X0_12
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X0_M10 X3_X0_13 N_X3_X0_7_X3_X0_M10_g N_GROUND_X3_X0_M9_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X0_M11 N_27_X3_X0_M11_d N_CLK_X3_X0_M11_g X3_X0_13 N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX3_X0_M12 N_GROUND_X3_X0_M12_d N_X3_X0_16_X3_X0_M12_g N_X3_X0_14_X3_X0_M12_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X0_M13 N_X3_X0_15_X3_X0_M13_d N_CLK_X3_X0_M13_g N_GROUND_X3_X0_M12_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X0_M14 N_VDD_X3_X0_M14_d N_X3_X0_16_X3_X0_M14_g N_X3_X0_14_X3_X0_M14_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX3_X0_M15 N_X3_X0_15_X3_X0_M15_d N_CLK_X3_X0_M15_g N_VDD_X3_X0_M14_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX3_X0_M16 N_VDD_X3_X0_M16_d N_X3_X0_7_X3_X0_M16_g N_X3_X0_10_X3_X0_M16_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX3_X0_M17 N_X3_X0_7_X3_X0_M17_d N_X3_X0_10_X3_X0_M17_g N_VDD_X3_X0_M16_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX3_X0_M18 N_VDD_X3_X0_M18_d N_X3_X0_11_X3_X0_M18_g N_27_X3_X0_M18_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX3_X0_M19 N_X3_X0_11_X3_X0_M19_d N_27_X3_X0_M19_g N_VDD_X3_X0_M18_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX3_X0_X20_M0 N_X3_X0_16_X3_X0_X20_M0_d N_X3_X0_X20_7_X3_X0_X20_M0_g
+ N_27_X3_X0_X20_M0_s N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X0_X20_M1 N_BUSW_X3_X0_X20_M1_d N_16_X3_X0_X20_M1_g
+ N_X3_X0_16_X3_X0_X20_M0_d N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X0_X20_M2 N_X3_X0_X20_7_X3_X0_X20_M2_d N_16_X3_X0_X20_M2_g
+ N_GROUND_X3_X0_X20_M2_s N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X0_X20_M3 N_X3_X0_16_X3_X0_X20_M3_d N_16_X3_X0_X20_M3_g N_27_X3_X0_X20_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX3_X0_X20_M4 N_BUSW_X3_X0_X20_M4_d N_X3_X0_X20_7_X3_X0_X20_M4_g
+ N_X3_X0_16_X3_X0_X20_M3_d N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX3_X0_X20_M5 N_X3_X0_X20_7_X3_X0_X20_M5_d N_16_X3_X0_X20_M5_g
+ N_VDD_X3_X0_X20_M5_s N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX3_X1_M0 N_GROUND_X3_X1_M0_d N_X3_X1_11_X3_X1_M0_g N_28_X3_X1_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X1_M1 N_X3_X1_7_X3_X1_M1_d N_X3_X1_10_X3_X1_M1_g N_GROUND_X3_X1_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X1_M2 X3_X1_8 N_X3_X1_15_X3_X1_M2_g N_X3_X1_7_X3_X1_M1_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X1_M3 N_GROUND_X3_X1_M3_d N_X3_X1_16_X3_X1_M3_g X3_X1_8
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X1_M4 X3_X1_9 N_X3_X1_14_X3_X1_M4_g N_GROUND_X3_X1_M3_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X1_M5 N_X3_X1_10_X3_X1_M5_d N_X3_X1_15_X3_X1_M5_g X3_X1_9
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X1_M6 N_GROUND_X3_X1_M6_d N_X3_X1_7_X3_X1_M6_g N_X3_X1_10_X3_X1_M5_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X1_M7 N_X3_X1_11_X3_X1_M7_d N_28_X3_X1_M7_g N_GROUND_X3_X1_M6_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X1_M8 X3_X1_12 N_CLK_X3_X1_M8_g N_X3_X1_11_X3_X1_M8_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X1_M9 N_GROUND_X3_X1_M9_d N_X3_X1_10_X3_X1_M9_g X3_X1_12
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X1_M10 X3_X1_13 N_X3_X1_7_X3_X1_M10_g N_GROUND_X3_X1_M9_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X1_M11 N_28_X3_X1_M11_d N_CLK_X3_X1_M11_g X3_X1_13 N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX3_X1_M12 N_GROUND_X3_X1_M12_d N_X3_X1_16_X3_X1_M12_g N_X3_X1_14_X3_X1_M12_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X1_M13 N_X3_X1_15_X3_X1_M13_d N_CLK_X3_X1_M13_g N_GROUND_X3_X1_M12_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X1_M14 N_VDD_X3_X1_M14_d N_X3_X1_16_X3_X1_M14_g N_X3_X1_14_X3_X1_M14_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX3_X1_M15 N_X3_X1_15_X3_X1_M15_d N_CLK_X3_X1_M15_g N_VDD_X3_X1_M14_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX3_X1_M16 N_VDD_X3_X1_M16_d N_X3_X1_7_X3_X1_M16_g N_X3_X1_10_X3_X1_M16_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX3_X1_M17 N_X3_X1_7_X3_X1_M17_d N_X3_X1_10_X3_X1_M17_g N_VDD_X3_X1_M16_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX3_X1_M18 N_VDD_X3_X1_M18_d N_X3_X1_11_X3_X1_M18_g N_28_X3_X1_M18_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX3_X1_M19 N_X3_X1_11_X3_X1_M19_d N_28_X3_X1_M19_g N_VDD_X3_X1_M18_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=6e-07
mX3_X1_X20_M0 N_X3_X1_16_X3_X1_X20_M0_d N_X3_X1_X20_7_X3_X1_X20_M0_g
+ N_28_X3_X1_X20_M0_s N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X1_X20_M1 N_BUSW_X3_X1_X20_M1_d N_19_X3_X1_X20_M1_g
+ N_X3_X1_16_X3_X1_X20_M0_d N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X1_X20_M2 N_X3_X1_X20_7_X3_X1_X20_M2_d N_19_X3_X1_X20_M2_g
+ N_GROUND_X3_X1_X20_M2_s N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX3_X1_X20_M3 N_X3_X1_16_X3_X1_X20_M3_d N_19_X3_X1_X20_M3_g N_28_X3_X1_X20_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX3_X1_X20_M4 N_BUSW_X3_X1_X20_M4_d N_X3_X1_X20_7_X3_X1_X20_M4_g
+ N_X3_X1_16_X3_X1_X20_M3_d N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX3_X1_X20_M5 N_X3_X1_X20_7_X3_X1_X20_M5_d N_19_X3_X1_X20_M5_g
+ N_VDD_X3_X1_X20_M5_s N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_M0 X4_X0_7 N_DEC0_X4_X0_M0_g N_X4_X0_6_X4_X0_M0_s N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX4_X0_M1 N_GROUND_X4_X0_M1_d N_REG_W_X4_X0_M1_g X4_X0_7 N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX4_X0_M2 N_4_X4_X0_M2_d N_X4_X0_6_X4_X0_M2_g N_GROUND_X4_X0_M1_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_M3 N_X4_X0_6_X4_X0_M3_d N_DEC0_X4_X0_M3_g N_VDD_X4_X0_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_M4 N_VDD_X4_X0_M4_d N_REG_W_X4_X0_M4_g N_X4_X0_6_X4_X0_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_M5 N_4_X4_X0_M5_d N_X4_X0_6_X4_X0_M5_g N_VDD_X4_X0_M4_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_M0 X4_X1_7 N_DEC1_X4_X1_M0_g N_X4_X1_6_X4_X1_M0_s N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX4_X1_M1 N_GROUND_X4_X1_M1_d N_REG_W_X4_X1_M1_g X4_X1_7 N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX4_X1_M2 N_6_X4_X1_M2_d N_X4_X1_6_X4_X1_M2_g N_GROUND_X4_X1_M1_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_M3 N_X4_X1_6_X4_X1_M3_d N_DEC1_X4_X1_M3_g N_VDD_X4_X1_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_M4 N_VDD_X4_X1_M4_d N_REG_W_X4_X1_M4_g N_X4_X1_6_X4_X1_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_M5 N_6_X4_X1_M5_d N_X4_X1_6_X4_X1_M5_g N_VDD_X4_X1_M4_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_M0 X5_X0_7 N_DEC2_X5_X0_M0_g N_X5_X0_6_X5_X0_M0_s N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX5_X0_M1 N_GROUND_X5_X0_M1_d N_REG_W_X5_X0_M1_g X5_X0_7 N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX5_X0_M2 N_8_X5_X0_M2_d N_X5_X0_6_X5_X0_M2_g N_GROUND_X5_X0_M1_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_M3 N_X5_X0_6_X5_X0_M3_d N_DEC2_X5_X0_M3_g N_VDD_X5_X0_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_M4 N_VDD_X5_X0_M4_d N_REG_W_X5_X0_M4_g N_X5_X0_6_X5_X0_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_M5 N_8_X5_X0_M5_d N_X5_X0_6_X5_X0_M5_g N_VDD_X5_X0_M4_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_M0 X5_X1_7 N_DEC3_X5_X1_M0_g N_X5_X1_6_X5_X1_M0_s N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX5_X1_M1 N_GROUND_X5_X1_M1_d N_REG_W_X5_X1_M1_g X5_X1_7 N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX5_X1_M2 N_10_X5_X1_M2_d N_X5_X1_6_X5_X1_M2_g N_GROUND_X5_X1_M1_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_M3 N_X5_X1_6_X5_X1_M3_d N_DEC3_X5_X1_M3_g N_VDD_X5_X1_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_M4 N_VDD_X5_X1_M4_d N_REG_W_X5_X1_M4_g N_X5_X1_6_X5_X1_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_M5 N_10_X5_X1_M5_d N_X5_X1_6_X5_X1_M5_g N_VDD_X5_X1_M4_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_M0 X6_X0_7 N_DEC4_X6_X0_M0_g N_X6_X0_6_X6_X0_M0_s N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX6_X0_M1 N_GROUND_X6_X0_M1_d N_REG_W_X6_X0_M1_g X6_X0_7 N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX6_X0_M2 N_12_X6_X0_M2_d N_X6_X0_6_X6_X0_M2_g N_GROUND_X6_X0_M1_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_M3 N_X6_X0_6_X6_X0_M3_d N_DEC4_X6_X0_M3_g N_VDD_X6_X0_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_M4 N_VDD_X6_X0_M4_d N_REG_W_X6_X0_M4_g N_X6_X0_6_X6_X0_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_M5 N_12_X6_X0_M5_d N_X6_X0_6_X6_X0_M5_g N_VDD_X6_X0_M4_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_M0 X6_X1_7 N_DEC5_X6_X1_M0_g N_X6_X1_6_X6_X1_M0_s N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX6_X1_M1 N_GROUND_X6_X1_M1_d N_REG_W_X6_X1_M1_g X6_X1_7 N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX6_X1_M2 N_14_X6_X1_M2_d N_X6_X1_6_X6_X1_M2_g N_GROUND_X6_X1_M1_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_M3 N_X6_X1_6_X6_X1_M3_d N_DEC5_X6_X1_M3_g N_VDD_X6_X1_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_M4 N_VDD_X6_X1_M4_d N_REG_W_X6_X1_M4_g N_X6_X1_6_X6_X1_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_M5 N_14_X6_X1_M5_d N_X6_X1_6_X6_X1_M5_g N_VDD_X6_X1_M4_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_M0 X7_X0_7 N_DEC6_X7_X0_M0_g N_X7_X0_6_X7_X0_M0_s N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX7_X0_M1 N_GROUND_X7_X0_M1_d N_REG_W_X7_X0_M1_g X7_X0_7 N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX7_X0_M2 N_16_X7_X0_M2_d N_X7_X0_6_X7_X0_M2_g N_GROUND_X7_X0_M1_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X0_M3 N_X7_X0_6_X7_X0_M3_d N_DEC6_X7_X0_M3_g N_VDD_X7_X0_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_M4 N_VDD_X7_X0_M4_d N_REG_W_X7_X0_M4_g N_X7_X0_6_X7_X0_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_M5 N_16_X7_X0_M5_d N_X7_X0_6_X7_X0_M5_g N_VDD_X7_X0_M4_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_M0 X7_X1_7 N_DEC7_X7_X1_M0_g N_X7_X1_6_X7_X1_M0_s N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX7_X1_M1 N_GROUND_X7_X1_M1_d N_REG_W_X7_X1_M1_g X7_X1_7 N_GROUND_X0_X0_X20_M0_b
+ NMOS L=1.3e-07 W=1.2e-06
mX7_X1_M2 N_19_X7_X1_M2_d N_X7_X1_6_X7_X1_M2_g N_GROUND_X7_X1_M1_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_M3 N_X7_X1_6_X7_X1_M3_d N_DEC7_X7_X1_M3_g N_VDD_X7_X1_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_M4 N_VDD_X7_X1_M4_d N_REG_W_X7_X1_M4_g N_X7_X1_6_X7_X1_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_M5 N_19_X7_X1_M5_d N_X7_X1_6_X7_X1_M5_g N_VDD_X7_X1_M4_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X0_M0 N_X8_15_X8_X0_M0_d N_X8_X0_7_X8_X0_M0_g N_20_X8_X0_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X0_M1 N_21_X8_X0_M1_d N_RT0_X8_X0_M1_g N_X8_15_X8_X0_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X0_M2 N_X8_X0_7_X8_X0_M2_d N_RT0_X8_X0_M2_g N_GROUND_X8_X0_M2_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X0_M3 N_X8_15_X8_X0_M3_d N_RT0_X8_X0_M3_g N_20_X8_X0_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X0_M4 N_21_X8_X0_M4_d N_X8_X0_7_X8_X0_M4_g N_X8_15_X8_X0_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X0_M5 N_X8_X0_7_X8_X0_M5_d N_RT0_X8_X0_M5_g N_VDD_X8_X0_M5_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X1_M0 N_X8_16_X8_X1_M0_d N_X8_X1_7_X8_X1_M0_g N_22_X8_X1_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X1_M1 N_23_X8_X1_M1_d N_RT0_X8_X1_M1_g N_X8_16_X8_X1_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X1_M2 N_X8_X1_7_X8_X1_M2_d N_RT0_X8_X1_M2_g N_GROUND_X8_X1_M2_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X1_M3 N_X8_16_X8_X1_M3_d N_RT0_X8_X1_M3_g N_22_X8_X1_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X1_M4 N_23_X8_X1_M4_d N_X8_X1_7_X8_X1_M4_g N_X8_16_X8_X1_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X1_M5 N_X8_X1_7_X8_X1_M5_d N_RT0_X8_X1_M5_g N_VDD_X8_X1_M5_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X2_M0 N_X8_19_X8_X2_M0_d N_X8_X2_7_X8_X2_M0_g N_X8_15_X8_X2_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X2_M1 N_X8_16_X8_X2_M1_d N_RT1_X8_X2_M1_g N_X8_19_X8_X2_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X2_M2 N_X8_X2_7_X8_X2_M2_d N_RT1_X8_X2_M2_g N_GROUND_X8_X2_M2_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X2_M3 N_X8_19_X8_X2_M3_d N_RT1_X8_X2_M3_g N_X8_15_X8_X2_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X2_M4 N_X8_16_X8_X2_M4_d N_X8_X2_7_X8_X2_M4_g N_X8_19_X8_X2_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X2_M5 N_X8_X2_7_X8_X2_M5_d N_RT1_X8_X2_M5_g N_VDD_X8_X2_M5_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X3_M0 N_X8_17_X8_X3_M0_d N_X8_X3_7_X8_X3_M0_g N_24_X8_X3_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X3_M1 N_26_X8_X3_M1_d N_RT0_X8_X3_M1_g N_X8_17_X8_X3_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X3_M2 N_X8_X3_7_X8_X3_M2_d N_RT0_X8_X3_M2_g N_GROUND_X8_X3_M2_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X3_M3 N_X8_17_X8_X3_M3_d N_RT0_X8_X3_M3_g N_24_X8_X3_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X3_M4 N_26_X8_X3_M4_d N_X8_X3_7_X8_X3_M4_g N_X8_17_X8_X3_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X3_M5 N_X8_X3_7_X8_X3_M5_d N_RT0_X8_X3_M5_g N_VDD_X8_X3_M5_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X4_M0 N_X8_18_X8_X4_M0_d N_X8_X4_7_X8_X4_M0_g N_27_X8_X4_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X4_M1 N_28_X8_X4_M1_d N_RT0_X8_X4_M1_g N_X8_18_X8_X4_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X4_M2 N_X8_X4_7_X8_X4_M2_d N_RT0_X8_X4_M2_g N_GROUND_X8_X4_M2_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X4_M3 N_X8_18_X8_X4_M3_d N_RT0_X8_X4_M3_g N_27_X8_X4_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X4_M4 N_28_X8_X4_M4_d N_X8_X4_7_X8_X4_M4_g N_X8_18_X8_X4_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X4_M5 N_X8_X4_7_X8_X4_M5_d N_RT0_X8_X4_M5_g N_VDD_X8_X4_M5_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X5_M0 N_X8_20_X8_X5_M0_d N_X8_X5_7_X8_X5_M0_g N_X8_17_X8_X5_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X5_M1 N_X8_18_X8_X5_M1_d N_RT1_X8_X5_M1_g N_X8_20_X8_X5_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X5_M2 N_X8_X5_7_X8_X5_M2_d N_RT1_X8_X5_M2_g N_GROUND_X8_X5_M2_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X5_M3 N_X8_20_X8_X5_M3_d N_RT1_X8_X5_M3_g N_X8_17_X8_X5_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X5_M4 N_X8_18_X8_X5_M4_d N_X8_X5_7_X8_X5_M4_g N_X8_20_X8_X5_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X5_M5 N_X8_X5_7_X8_X5_M5_d N_RT1_X8_X5_M5_g N_VDD_X8_X5_M5_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X6_M0 N_BUSA_X8_X6_M0_d N_X8_X6_7_X8_X6_M0_g N_X8_19_X8_X6_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X6_M1 N_X8_20_X8_X6_M1_d N_RT2_X8_X6_M1_g N_BUSA_X8_X6_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X6_M2 N_X8_X6_7_X8_X6_M2_d N_RT2_X8_X6_M2_g N_GROUND_X8_X6_M2_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X6_M3 N_BUSA_X8_X6_M3_d N_RT2_X8_X6_M3_g N_X8_19_X8_X6_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X6_M4 N_X8_20_X8_X6_M4_d N_X8_X6_7_X8_X6_M4_g N_BUSA_X8_X6_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X6_M5 N_X8_X6_7_X8_X6_M5_d N_RT2_X8_X6_M5_g N_VDD_X8_X6_M5_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X0_M0 N_X9_15_X9_X0_M0_d N_X9_X0_7_X9_X0_M0_g N_20_X9_X0_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X0_M1 N_21_X9_X0_M1_d N_RS0_X9_X0_M1_g N_X9_15_X9_X0_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X0_M2 N_X9_X0_7_X9_X0_M2_d N_RS0_X9_X0_M2_g N_GROUND_X9_X0_M2_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X0_M3 N_X9_15_X9_X0_M3_d N_RS0_X9_X0_M3_g N_20_X9_X0_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X0_M4 N_21_X9_X0_M4_d N_X9_X0_7_X9_X0_M4_g N_X9_15_X9_X0_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X0_M5 N_X9_X0_7_X9_X0_M5_d N_RS0_X9_X0_M5_g N_VDD_X9_X0_M5_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X1_M0 N_X9_16_X9_X1_M0_d N_X9_X1_7_X9_X1_M0_g N_22_X9_X1_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X1_M1 N_23_X9_X1_M1_d N_RS0_X9_X1_M1_g N_X9_16_X9_X1_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X1_M2 N_X9_X1_7_X9_X1_M2_d N_RS0_X9_X1_M2_g N_GROUND_X9_X1_M2_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X1_M3 N_X9_16_X9_X1_M3_d N_RS0_X9_X1_M3_g N_22_X9_X1_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X1_M4 N_23_X9_X1_M4_d N_X9_X1_7_X9_X1_M4_g N_X9_16_X9_X1_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X1_M5 N_X9_X1_7_X9_X1_M5_d N_RS0_X9_X1_M5_g N_VDD_X9_X1_M5_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X2_M0 N_X9_19_X9_X2_M0_d N_X9_X2_7_X9_X2_M0_g N_X9_15_X9_X2_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X2_M1 N_X9_16_X9_X2_M1_d N_RS1_X9_X2_M1_g N_X9_19_X9_X2_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X2_M2 N_X9_X2_7_X9_X2_M2_d N_RS1_X9_X2_M2_g N_GROUND_X9_X2_M2_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X2_M3 N_X9_19_X9_X2_M3_d N_RS1_X9_X2_M3_g N_X9_15_X9_X2_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X2_M4 N_X9_16_X9_X2_M4_d N_X9_X2_7_X9_X2_M4_g N_X9_19_X9_X2_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X2_M5 N_X9_X2_7_X9_X2_M5_d N_RS1_X9_X2_M5_g N_VDD_X9_X2_M5_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X3_M0 N_X9_17_X9_X3_M0_d N_X9_X3_7_X9_X3_M0_g N_24_X9_X3_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X3_M1 N_26_X9_X3_M1_d N_RS0_X9_X3_M1_g N_X9_17_X9_X3_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X3_M2 N_X9_X3_7_X9_X3_M2_d N_RS0_X9_X3_M2_g N_GROUND_X9_X3_M2_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X3_M3 N_X9_17_X9_X3_M3_d N_RS0_X9_X3_M3_g N_24_X9_X3_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X3_M4 N_26_X9_X3_M4_d N_X9_X3_7_X9_X3_M4_g N_X9_17_X9_X3_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X3_M5 N_X9_X3_7_X9_X3_M5_d N_RS0_X9_X3_M5_g N_VDD_X9_X3_M5_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X4_M0 N_X9_18_X9_X4_M0_d N_X9_X4_7_X9_X4_M0_g N_27_X9_X4_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X4_M1 N_28_X9_X4_M1_d N_RS0_X9_X4_M1_g N_X9_18_X9_X4_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X4_M2 N_X9_X4_7_X9_X4_M2_d N_RS0_X9_X4_M2_g N_GROUND_X9_X4_M2_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X4_M3 N_X9_18_X9_X4_M3_d N_RS0_X9_X4_M3_g N_27_X9_X4_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X4_M4 N_28_X9_X4_M4_d N_X9_X4_7_X9_X4_M4_g N_X9_18_X9_X4_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X4_M5 N_X9_X4_7_X9_X4_M5_d N_RS0_X9_X4_M5_g N_VDD_X9_X4_M5_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X5_M0 N_X9_20_X9_X5_M0_d N_X9_X5_7_X9_X5_M0_g N_X9_17_X9_X5_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X5_M1 N_X9_18_X9_X5_M1_d N_RS1_X9_X5_M1_g N_X9_20_X9_X5_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X5_M2 N_X9_X5_7_X9_X5_M2_d N_RS1_X9_X5_M2_g N_GROUND_X9_X5_M2_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X5_M3 N_X9_20_X9_X5_M3_d N_RS1_X9_X5_M3_g N_X9_17_X9_X5_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X5_M4 N_X9_18_X9_X5_M4_d N_X9_X5_7_X9_X5_M4_g N_X9_20_X9_X5_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X5_M5 N_X9_X5_7_X9_X5_M5_d N_RS1_X9_X5_M5_g N_VDD_X9_X5_M5_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X6_M0 N_BUSB_X9_X6_M0_d N_X9_X6_7_X9_X6_M0_g N_X9_19_X9_X6_M0_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X6_M1 N_X9_20_X9_X6_M1_d N_RS2_X9_X6_M1_g N_BUSB_X9_X6_M0_d
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X6_M2 N_X9_X6_7_X9_X6_M2_d N_RS2_X9_X6_M2_g N_GROUND_X9_X6_M2_s
+ N_GROUND_X0_X0_X20_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X6_M3 N_BUSB_X9_X6_M3_d N_RS2_X9_X6_M3_g N_X9_19_X9_X6_M3_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X6_M4 N_X9_20_X9_X6_M4_d N_X9_X6_7_X9_X6_M4_g N_BUSB_X9_X6_M3_d
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X6_M5 N_X9_X6_7_X9_X6_M5_d N_RS2_X9_X6_M5_g N_VDD_X9_X6_M5_s
+ N_VDD_X0_X0_X20_M3_b PMOS L=1.3e-07 W=1.35e-06
*
.include "reg.pex.netlist.REG.pxi"
*
.End
*
*
