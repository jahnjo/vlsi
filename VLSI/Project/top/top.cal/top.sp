*  Spice netlist top.pex.netlist transformed for AMS-Sim
*    additions

.LIB $MGC_DESIGN_KIT/models/lib.eldo TT

Vvdd VDD 0 2.5
Vgnd ground 0 0

*  Here begins the original spice file

* File: top.pex.netlist
* Created: Mon Apr 29 13:37:22 2019
* Program "Calibre xRC"
* Version "v2012.2_36.25"
*
.global VDD VSS
.include "top.pex.netlist.pex"
*
* OP2	OP2
* PCSRC	PCSRC
* ALUSRC	ALUSRC
* OP0	OP0
* OP1	OP1
* RT2	RT2
* RT1	RT1
* RT0	RT0
* RS2	RS2
* CLK	CLK
* RS1	RS1
* RS0	RS0
* RD0	RD0
* RD2	RD2
* RD1	RD1
* IMM1	IMM1
* RESULT2	RESULT2
* IMM0	IMM0
* INPUT_SELECT	INPUT_SELECT
* RESULT3	RESULT3
* IMM2	IMM2
* RESULT1	RESULT1
* IMM3	IMM3
* RESULT0	RESULT0
* GROUND	GROUND
* VDD	VDD
mX0_M0 N_4_X0_M0_d N_X0_7_X0_M0_g N_RESULT0_X0_M0_s N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX0_M1 N_IMM3_X0_M1_d N_INPUT_SELECT_X0_M1_g N_4_X0_M0_d N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX0_M2 N_X0_7_X0_M2_d N_INPUT_SELECT_X0_M2_g N_GROUND_X0_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX0_M3 N_4_X0_M3_d N_INPUT_SELECT_X0_M3_g N_RESULT0_X0_M3_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX0_M4 N_IMM3_X0_M4_d N_X0_7_X0_M4_g N_4_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX0_M5 N_X0_7_X0_M5_d N_INPUT_SELECT_X0_M5_g N_VDD_X0_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX1_M0 N_7_X1_M0_d N_X1_7_X1_M0_g N_RESULT1_X1_M0_s N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX1_M1 N_IMM2_X1_M1_d N_INPUT_SELECT_X1_M1_g N_7_X1_M0_d N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX1_M2 N_X1_7_X1_M2_d N_INPUT_SELECT_X1_M2_g N_GROUND_X1_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX1_M3 N_7_X1_M3_d N_INPUT_SELECT_X1_M3_g N_RESULT1_X1_M3_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX1_M4 N_IMM2_X1_M4_d N_X1_7_X1_M4_g N_7_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX1_M5 N_X1_7_X1_M5_d N_INPUT_SELECT_X1_M5_g N_VDD_X1_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX2_M0 N_11_X2_M0_d N_X2_7_X2_M0_g N_RESULT3_X2_M0_s N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX2_M1 N_IMM0_X2_M1_d N_INPUT_SELECT_X2_M1_g N_11_X2_M0_d N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX2_M2 N_X2_7_X2_M2_d N_INPUT_SELECT_X2_M2_g N_GROUND_X2_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX2_M3 N_11_X2_M3_d N_INPUT_SELECT_X2_M3_g N_RESULT3_X2_M3_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX2_M4 N_IMM0_X2_M4_d N_X2_7_X2_M4_g N_11_X2_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX2_M5 N_X2_7_X2_M5_d N_INPUT_SELECT_X2_M5_g N_VDD_X2_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX3_M0 N_14_X3_M0_d N_X3_7_X3_M0_g N_RESULT2_X3_M0_s N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX3_M1 N_IMM1_X3_M1_d N_INPUT_SELECT_X3_M1_g N_14_X3_M0_d N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX3_M2 N_X3_7_X3_M2_d N_INPUT_SELECT_X3_M2_g N_GROUND_X3_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX3_M3 N_14_X3_M3_d N_INPUT_SELECT_X3_M3_g N_RESULT2_X3_M3_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX3_M4 N_IMM1_X3_M4_d N_X3_7_X3_M4_g N_14_X3_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=1.35e-06
mX3_M5 N_X3_7_X3_M5_d N_INPUT_SELECT_X3_M5_g N_VDD_X3_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX4_X0_M0 X4_X0_11 N_28_X4_X0_M0_g N_X4_X0_10_X4_X0_M0_s N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=2e-06
mX4_X0_M1 X4_X0_12 N_X4_X0_23_X4_X0_M1_g X4_X0_11 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=2e-06
mX4_X0_M2 N_GROUND_X4_X0_M2_d N_X4_47_X4_X0_M2_g X4_X0_12 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=2e-06
mX4_X0_M3 N_27_X4_X0_M3_d N_X4_X0_16_X4_X0_M3_g N_GROUND_X4_X0_M2_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX4_X0_M4 N_GROUND_X4_X0_M4_d N_X4_X0_10_X4_X0_M4_g N_X4_X0_13_X4_X0_M4_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX4_X0_M5 N_X4_X0_14_X4_X0_M5_d N_28_X4_X0_M5_g N_GROUND_X4_X0_M4_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX4_X0_M6 N_GROUND_X4_X0_M6_d N_X4_X0_23_X4_X0_M6_g N_X4_X0_14_X4_X0_M5_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX4_X0_M7 N_X4_X0_14_X4_X0_M7_d N_X4_47_X4_X0_M7_g N_GROUND_X4_X0_M6_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX4_X0_M8 N_X4_X0_10_X4_X0_M8_d N_X4_X0_16_X4_X0_M8_g N_X4_X0_14_X4_X0_M7_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX4_X0_M9 N_X4_X0_15_X4_X0_M9_d N_X4_X0_23_X4_X0_M9_g N_GROUND_X4_X0_M9_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX4_X0_M10 N_X4_X0_16_X4_X0_M10_d N_28_X4_X0_M10_g N_X4_X0_15_X4_X0_M9_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX4_X0_M11 X4_X0_17 N_X4_47_X4_X0_M11_g N_X4_X0_16_X4_X0_M10_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=2e-06
mX4_X0_M12 N_GROUND_X4_X0_M12_d N_X4_X0_23_X4_X0_M12_g X4_X0_17 N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=2e-06
mX4_X0_M13 N_X4_X0_15_X4_X0_M13_d N_X4_47_X4_X0_M13_g N_GROUND_X4_X0_M12_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX4_X0_M14 N_X4_X0_16_X4_X0_M14_d N_28_X4_X0_M14_g N_X4_X0_18_X4_X0_M14_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX4_X0_M15 X4_X0_19 N_X4_47_X4_X0_M15_g N_X4_X0_16_X4_X0_M14_d N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=2e-06
mX4_X0_M16 N_VDD_X4_X0_M16_d N_X4_X0_23_X4_X0_M16_g X4_X0_19 N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=2e-06
mX4_X0_M17 N_X4_X0_18_X4_X0_M17_d N_X4_X0_23_X4_X0_M17_g N_VDD_X4_X0_M16_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX4_X0_M18 N_VDD_X4_X0_M18_d N_X4_47_X4_X0_M18_g N_X4_X0_18_X4_X0_M17_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX4_X0_M19 X4_X0_20 N_X4_47_X4_X0_M19_g N_VDD_X4_X0_M18_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=2e-06
mX4_X0_M20 X4_X0_21 N_X4_X0_23_X4_X0_M20_g X4_X0_20 N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=2e-06
mX4_X0_M21 N_X4_X0_10_X4_X0_M21_d N_28_X4_X0_M21_g X4_X0_21 N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=2e-06
mX4_X0_M22 N_X4_X0_22_X4_X0_M22_d N_X4_X0_16_X4_X0_M22_g N_X4_X0_10_X4_X0_M21_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX4_X0_M23 N_VDD_X4_X0_M23_d N_X4_X0_16_X4_X0_M23_g N_27_X4_X0_M23_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX4_X0_M24 N_X4_X0_22_X4_X0_M24_d N_X4_47_X4_X0_M24_g N_VDD_X4_X0_M23_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX4_X0_M25 N_VDD_X4_X0_M25_d N_X4_X0_23_X4_X0_M25_g N_X4_X0_22_X4_X0_M24_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX4_X0_M26 N_X4_X0_22_X4_X0_M26_d N_28_X4_X0_M26_g N_VDD_X4_X0_M25_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX4_X0_M27 N_X4_X0_13_X4_X0_M27_d N_X4_X0_10_X4_X0_M27_g N_VDD_X4_X0_M27_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX4_X0_X28_M0 N_X4_X0_X28_6_X4_X0_X28_M0_d N_X4_48_X4_X0_X28_M0_g
+ N_GROUND_X4_X0_X28_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_X28_M1 N_GROUND_X4_X0_X28_M1_d N_X4_47_X4_X0_X28_M1_g
+ N_X4_X0_X28_6_X4_X0_X28_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_X28_M2 N_X4_X0_24_X4_X0_X28_M2_d N_X4_X0_X28_6_X4_X0_X28_M2_g
+ N_GROUND_X4_X0_X28_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_X28_M3 N_VDD_X4_X0_X28_M3_d N_X4_X0_X28_6_X4_X0_X28_M3_g
+ N_X4_X0_24_X4_X0_X28_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_X28_M4 X4_X0_X28_7 N_X4_47_X4_X0_X28_M4_g N_VDD_X4_X0_X28_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX4_X0_X28_M5 N_X4_X0_X28_6_X4_X0_X28_M5_d N_X4_48_X4_X0_X28_M5_g X4_X0_X28_7
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX4_X0_X29_M0 N_X4_X0_25_X4_X0_X29_M0_d N_X4_48_X4_X0_X29_M0_g
+ N_GROUND_X4_X0_X29_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_X29_M1 N_X4_X0_25_X4_X0_X29_M1_d N_X4_48_X4_X0_X29_M1_g
+ N_VDD_X4_X0_X29_M1_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_X30_M0 N_X4_X0_23_X4_X0_X30_M0_d N_X4_X0_X30_7_X4_X0_X30_M0_g
+ N_X4_48_X4_X0_X30_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_X30_M1 N_X4_X0_25_X4_X0_X30_M1_d N_29_X4_X0_X30_M1_g
+ N_X4_X0_23_X4_X0_X30_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_X30_M2 N_X4_X0_X30_7_X4_X0_X30_M2_d N_29_X4_X0_X30_M2_g
+ N_GROUND_X4_X0_X30_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_X30_M3 N_X4_X0_23_X4_X0_X30_M3_d N_29_X4_X0_X30_M3_g
+ N_X4_48_X4_X0_X30_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_X30_M4 N_X4_X0_25_X4_X0_X30_M4_d N_X4_X0_X30_7_X4_X0_X30_M4_g
+ N_X4_X0_23_X4_X0_X30_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_X30_M5 N_X4_X0_X30_7_X4_X0_X30_M5_d N_29_X4_X0_X30_M5_g
+ N_VDD_X4_X0_X30_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_X31_M0 N_X4_X0_27_X4_X0_X31_M0_d N_X4_X0_X31_7_X4_X0_X31_M0_g
+ N_X4_X0_13_X4_X0_X31_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_X31_M1 N_X4_X0_13_X4_X0_X31_M1_d N_29_X4_X0_X31_M1_g
+ N_X4_X0_27_X4_X0_X31_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_X31_M2 N_X4_X0_X31_7_X4_X0_X31_M2_d N_29_X4_X0_X31_M2_g
+ N_GROUND_X4_X0_X31_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_X31_M3 N_X4_X0_27_X4_X0_X31_M3_d N_29_X4_X0_X31_M3_g
+ N_X4_X0_13_X4_X0_X31_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_X31_M4 N_X4_X0_13_X4_X0_X31_M4_d N_X4_X0_X31_7_X4_X0_X31_M4_g
+ N_X4_X0_27_X4_X0_X31_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_X31_M5 N_X4_X0_X31_7_X4_X0_X31_M5_d N_29_X4_X0_X31_M5_g
+ N_VDD_X4_X0_X31_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_X32_M0 N_RESULT3_X4_X0_X32_M0_d N_X4_X0_X32_7_X4_X0_X32_M0_g
+ N_X4_X0_27_X4_X0_X32_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_X32_M1 N_X4_X0_28_X4_X0_X32_M1_d N_30_X4_X0_X32_M1_g
+ N_RESULT3_X4_X0_X32_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_X32_M2 N_X4_X0_X32_7_X4_X0_X32_M2_d N_30_X4_X0_X32_M2_g
+ N_GROUND_X4_X0_X32_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_X32_M3 N_RESULT3_X4_X0_X32_M3_d N_30_X4_X0_X32_M3_g
+ N_X4_X0_27_X4_X0_X32_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_X32_M4 N_X4_X0_28_X4_X0_X32_M4_d N_X4_X0_X32_7_X4_X0_X32_M4_g
+ N_RESULT3_X4_X0_X32_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_X32_M5 N_X4_X0_X32_7_X4_X0_X32_M5_d N_30_X4_X0_X32_M5_g
+ N_VDD_X4_X0_X32_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_X33_M0 N_X4_X0_28_X4_X0_X33_M0_d N_X4_X0_X33_7_X4_X0_X33_M0_g
+ N_X4_X0_26_X4_X0_X33_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_X33_M1 N_X4_X0_24_X4_X0_X33_M1_d N_29_X4_X0_X33_M1_g
+ N_X4_X0_28_X4_X0_X33_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_X33_M2 N_X4_X0_X33_7_X4_X0_X33_M2_d N_29_X4_X0_X33_M2_g
+ N_GROUND_X4_X0_X33_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_X33_M3 N_X4_X0_28_X4_X0_X33_M3_d N_29_X4_X0_X33_M3_g
+ N_X4_X0_26_X4_X0_X33_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_X33_M4 N_X4_X0_24_X4_X0_X33_M4_d N_X4_X0_X33_7_X4_X0_X33_M4_g
+ N_X4_X0_28_X4_X0_X33_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_X33_M5 N_X4_X0_X33_7_X4_X0_X33_M5_d N_29_X4_X0_X33_M5_g
+ N_VDD_X4_X0_X33_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_X34_M0 X4_X0_X34_7 N_X4_47_X4_X0_X34_M0_g N_X4_X0_X34_6_X4_X0_X34_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX4_X0_X34_M1 N_GROUND_X4_X0_X34_M1_d N_X4_48_X4_X0_X34_M1_g X4_X0_X34_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX4_X0_X34_M2 N_X4_X0_26_X4_X0_X34_M2_d N_X4_X0_X34_6_X4_X0_X34_M2_g
+ N_GROUND_X4_X0_X34_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X0_X34_M3 N_X4_X0_X34_6_X4_X0_X34_M3_d N_X4_47_X4_X0_X34_M3_g
+ N_VDD_X4_X0_X34_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_X34_M4 N_VDD_X4_X0_X34_M4_d N_X4_48_X4_X0_X34_M4_g
+ N_X4_X0_X34_6_X4_X0_X34_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X0_X34_M5 N_X4_X0_26_X4_X0_X34_M5_d N_X4_X0_X34_6_X4_X0_X34_M5_g
+ N_VDD_X4_X0_X34_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X0_X0_M0 N_GROUND_X4_X1_X0_X0_M0_d N_X4_X1_X0_X0_11_X4_X1_X0_X0_M0_g
+ N_X4_X1_30_X4_X1_X0_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M1 N_X4_X1_X0_X0_7_X4_X1_X0_X0_M1_d
+ N_X4_X1_X0_X0_10_X4_X1_X0_X0_M1_g N_GROUND_X4_X1_X0_X0_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M2 X4_X1_X0_X0_8 N_X4_X1_X0_X0_15_X4_X1_X0_X0_M2_g
+ N_X4_X1_X0_X0_7_X4_X1_X0_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M3 N_GROUND_X4_X1_X0_X0_M3_d N_X4_X1_X0_X0_16_X4_X1_X0_X0_M3_g
+ X4_X1_X0_X0_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M4 X4_X1_X0_X0_9 N_X4_X1_X0_X0_14_X4_X1_X0_X0_M4_g
+ N_GROUND_X4_X1_X0_X0_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M5 N_X4_X1_X0_X0_10_X4_X1_X0_X0_M5_d
+ N_X4_X1_X0_X0_15_X4_X1_X0_X0_M5_g X4_X1_X0_X0_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M6 N_GROUND_X4_X1_X0_X0_M6_d N_X4_X1_X0_X0_7_X4_X1_X0_X0_M6_g
+ N_X4_X1_X0_X0_10_X4_X1_X0_X0_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M7 N_X4_X1_X0_X0_11_X4_X1_X0_X0_M7_d N_X4_X1_30_X4_X1_X0_X0_M7_g
+ N_GROUND_X4_X1_X0_X0_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M8 X4_X1_X0_X0_12 N_CLK_X4_X1_X0_X0_M8_g
+ N_X4_X1_X0_X0_11_X4_X1_X0_X0_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M9 N_GROUND_X4_X1_X0_X0_M9_d N_X4_X1_X0_X0_10_X4_X1_X0_X0_M9_g
+ X4_X1_X0_X0_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M10 X4_X1_X0_X0_13 N_X4_X1_X0_X0_7_X4_X1_X0_X0_M10_g
+ N_GROUND_X4_X1_X0_X0_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M11 N_X4_X1_30_X4_X1_X0_X0_M11_d N_CLK_X4_X1_X0_X0_M11_g
+ X4_X1_X0_X0_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M12 N_GROUND_X4_X1_X0_X0_M12_d N_X4_X1_X0_X0_16_X4_X1_X0_X0_M12_g
+ N_X4_X1_X0_X0_14_X4_X1_X0_X0_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M13 N_X4_X1_X0_X0_15_X4_X1_X0_X0_M13_d N_CLK_X4_X1_X0_X0_M13_g
+ N_GROUND_X4_X1_X0_X0_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M14 N_VDD_X4_X1_X0_X0_M14_d N_X4_X1_X0_X0_16_X4_X1_X0_X0_M14_g
+ N_X4_X1_X0_X0_14_X4_X1_X0_X0_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M15 N_X4_X1_X0_X0_15_X4_X1_X0_X0_M15_d N_CLK_X4_X1_X0_X0_M15_g
+ N_VDD_X4_X1_X0_X0_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M16 N_VDD_X4_X1_X0_X0_M16_d N_X4_X1_X0_X0_7_X4_X1_X0_X0_M16_g
+ N_X4_X1_X0_X0_10_X4_X1_X0_X0_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M17 N_X4_X1_X0_X0_7_X4_X1_X0_X0_M17_d
+ N_X4_X1_X0_X0_10_X4_X1_X0_X0_M17_g N_VDD_X4_X1_X0_X0_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M18 N_VDD_X4_X1_X0_X0_M18_d N_X4_X1_X0_X0_11_X4_X1_X0_X0_M18_g
+ N_X4_X1_30_X4_X1_X0_X0_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_M19 N_X4_X1_X0_X0_11_X4_X1_X0_X0_M19_d N_X4_X1_30_X4_X1_X0_X0_M19_g
+ N_VDD_X4_X1_X0_X0_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_X20_M0 N_X4_X1_X0_X0_16_X4_X1_X0_X0_X20_M0_d
+ N_X4_X1_X0_X0_X20_7_X4_X1_X0_X0_X20_M0_g N_X4_X1_30_X4_X1_X0_X0_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_X20_M1 N_4_X4_X1_X0_X0_X20_M1_d N_X4_X1_22_X4_X1_X0_X0_X20_M1_g
+ N_X4_X1_X0_X0_16_X4_X1_X0_X0_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_X20_M2 N_X4_X1_X0_X0_X20_7_X4_X1_X0_X0_X20_M2_d
+ N_X4_X1_22_X4_X1_X0_X0_X20_M2_g N_GROUND_X4_X1_X0_X0_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X0_X20_M3 N_X4_X1_X0_X0_16_X4_X1_X0_X0_X20_M3_d
+ N_X4_X1_22_X4_X1_X0_X0_X20_M3_g N_X4_X1_30_X4_X1_X0_X0_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X0_X0_X20_M4 N_4_X4_X1_X0_X0_X20_M4_d
+ N_X4_X1_X0_X0_X20_7_X4_X1_X0_X0_X20_M4_g N_X4_X1_X0_X0_16_X4_X1_X0_X0_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X0_X0_X20_M5 N_X4_X1_X0_X0_X20_7_X4_X1_X0_X0_X20_M5_d
+ N_X4_X1_22_X4_X1_X0_X0_X20_M5_g N_VDD_X4_X1_X0_X0_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX4_X1_X0_X1_M0 N_GROUND_X4_X1_X0_X1_M0_d N_X4_X1_X0_X1_11_X4_X1_X0_X1_M0_g
+ N_X4_X1_31_X4_X1_X0_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M1 N_X4_X1_X0_X1_7_X4_X1_X0_X1_M1_d
+ N_X4_X1_X0_X1_10_X4_X1_X0_X1_M1_g N_GROUND_X4_X1_X0_X1_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M2 X4_X1_X0_X1_8 N_X4_X1_X0_X1_15_X4_X1_X0_X1_M2_g
+ N_X4_X1_X0_X1_7_X4_X1_X0_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M3 N_GROUND_X4_X1_X0_X1_M3_d N_X4_X1_X0_X1_16_X4_X1_X0_X1_M3_g
+ X4_X1_X0_X1_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M4 X4_X1_X0_X1_9 N_X4_X1_X0_X1_14_X4_X1_X0_X1_M4_g
+ N_GROUND_X4_X1_X0_X1_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M5 N_X4_X1_X0_X1_10_X4_X1_X0_X1_M5_d
+ N_X4_X1_X0_X1_15_X4_X1_X0_X1_M5_g X4_X1_X0_X1_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M6 N_GROUND_X4_X1_X0_X1_M6_d N_X4_X1_X0_X1_7_X4_X1_X0_X1_M6_g
+ N_X4_X1_X0_X1_10_X4_X1_X0_X1_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M7 N_X4_X1_X0_X1_11_X4_X1_X0_X1_M7_d N_X4_X1_31_X4_X1_X0_X1_M7_g
+ N_GROUND_X4_X1_X0_X1_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M8 X4_X1_X0_X1_12 N_CLK_X4_X1_X0_X1_M8_g
+ N_X4_X1_X0_X1_11_X4_X1_X0_X1_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M9 N_GROUND_X4_X1_X0_X1_M9_d N_X4_X1_X0_X1_10_X4_X1_X0_X1_M9_g
+ X4_X1_X0_X1_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M10 X4_X1_X0_X1_13 N_X4_X1_X0_X1_7_X4_X1_X0_X1_M10_g
+ N_GROUND_X4_X1_X0_X1_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M11 N_X4_X1_31_X4_X1_X0_X1_M11_d N_CLK_X4_X1_X0_X1_M11_g
+ X4_X1_X0_X1_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M12 N_GROUND_X4_X1_X0_X1_M12_d N_X4_X1_X0_X1_16_X4_X1_X0_X1_M12_g
+ N_X4_X1_X0_X1_14_X4_X1_X0_X1_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M13 N_X4_X1_X0_X1_15_X4_X1_X0_X1_M13_d N_CLK_X4_X1_X0_X1_M13_g
+ N_GROUND_X4_X1_X0_X1_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M14 N_VDD_X4_X1_X0_X1_M14_d N_X4_X1_X0_X1_16_X4_X1_X0_X1_M14_g
+ N_X4_X1_X0_X1_14_X4_X1_X0_X1_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M15 N_X4_X1_X0_X1_15_X4_X1_X0_X1_M15_d N_CLK_X4_X1_X0_X1_M15_g
+ N_VDD_X4_X1_X0_X1_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M16 N_VDD_X4_X1_X0_X1_M16_d N_X4_X1_X0_X1_7_X4_X1_X0_X1_M16_g
+ N_X4_X1_X0_X1_10_X4_X1_X0_X1_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M17 N_X4_X1_X0_X1_7_X4_X1_X0_X1_M17_d
+ N_X4_X1_X0_X1_10_X4_X1_X0_X1_M17_g N_VDD_X4_X1_X0_X1_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M18 N_VDD_X4_X1_X0_X1_M18_d N_X4_X1_X0_X1_11_X4_X1_X0_X1_M18_g
+ N_X4_X1_31_X4_X1_X0_X1_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_M19 N_X4_X1_X0_X1_11_X4_X1_X0_X1_M19_d N_X4_X1_31_X4_X1_X0_X1_M19_g
+ N_VDD_X4_X1_X0_X1_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_X20_M0 N_X4_X1_X0_X1_16_X4_X1_X0_X1_X20_M0_d
+ N_X4_X1_X0_X1_X20_7_X4_X1_X0_X1_X20_M0_g N_X4_X1_31_X4_X1_X0_X1_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_X20_M1 N_4_X4_X1_X0_X1_X20_M1_d N_X4_X1_23_X4_X1_X0_X1_X20_M1_g
+ N_X4_X1_X0_X1_16_X4_X1_X0_X1_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_X20_M2 N_X4_X1_X0_X1_X20_7_X4_X1_X0_X1_X20_M2_d
+ N_X4_X1_23_X4_X1_X0_X1_X20_M2_g N_GROUND_X4_X1_X0_X1_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX4_X1_X0_X1_X20_M3 N_X4_X1_X0_X1_16_X4_X1_X0_X1_X20_M3_d
+ N_X4_X1_23_X4_X1_X0_X1_X20_M3_g N_X4_X1_31_X4_X1_X0_X1_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X0_X1_X20_M4 N_4_X4_X1_X0_X1_X20_M4_d
+ N_X4_X1_X0_X1_X20_7_X4_X1_X0_X1_X20_M4_g N_X4_X1_X0_X1_16_X4_X1_X0_X1_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X0_X1_X20_M5 N_X4_X1_X0_X1_X20_7_X4_X1_X0_X1_X20_M5_d
+ N_X4_X1_23_X4_X1_X0_X1_X20_M5_g N_VDD_X4_X1_X0_X1_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX4_X1_X1_X0_M0 N_GROUND_X4_X1_X1_X0_M0_d N_X4_X1_X1_X0_11_X4_X1_X1_X0_M0_g
+ N_X4_X1_32_X4_X1_X1_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M1 N_X4_X1_X1_X0_7_X4_X1_X1_X0_M1_d
+ N_X4_X1_X1_X0_10_X4_X1_X1_X0_M1_g N_GROUND_X4_X1_X1_X0_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M2 X4_X1_X1_X0_8 N_X4_X1_X1_X0_15_X4_X1_X1_X0_M2_g
+ N_X4_X1_X1_X0_7_X4_X1_X1_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M3 N_GROUND_X4_X1_X1_X0_M3_d N_X4_X1_X1_X0_16_X4_X1_X1_X0_M3_g
+ X4_X1_X1_X0_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M4 X4_X1_X1_X0_9 N_X4_X1_X1_X0_14_X4_X1_X1_X0_M4_g
+ N_GROUND_X4_X1_X1_X0_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M5 N_X4_X1_X1_X0_10_X4_X1_X1_X0_M5_d
+ N_X4_X1_X1_X0_15_X4_X1_X1_X0_M5_g X4_X1_X1_X0_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M6 N_GROUND_X4_X1_X1_X0_M6_d N_X4_X1_X1_X0_7_X4_X1_X1_X0_M6_g
+ N_X4_X1_X1_X0_10_X4_X1_X1_X0_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M7 N_X4_X1_X1_X0_11_X4_X1_X1_X0_M7_d N_X4_X1_32_X4_X1_X1_X0_M7_g
+ N_GROUND_X4_X1_X1_X0_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M8 X4_X1_X1_X0_12 N_CLK_X4_X1_X1_X0_M8_g
+ N_X4_X1_X1_X0_11_X4_X1_X1_X0_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M9 N_GROUND_X4_X1_X1_X0_M9_d N_X4_X1_X1_X0_10_X4_X1_X1_X0_M9_g
+ X4_X1_X1_X0_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M10 X4_X1_X1_X0_13 N_X4_X1_X1_X0_7_X4_X1_X1_X0_M10_g
+ N_GROUND_X4_X1_X1_X0_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M11 N_X4_X1_32_X4_X1_X1_X0_M11_d N_CLK_X4_X1_X1_X0_M11_g
+ X4_X1_X1_X0_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M12 N_GROUND_X4_X1_X1_X0_M12_d N_X4_X1_X1_X0_16_X4_X1_X1_X0_M12_g
+ N_X4_X1_X1_X0_14_X4_X1_X1_X0_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M13 N_X4_X1_X1_X0_15_X4_X1_X1_X0_M13_d N_CLK_X4_X1_X1_X0_M13_g
+ N_GROUND_X4_X1_X1_X0_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M14 N_VDD_X4_X1_X1_X0_M14_d N_X4_X1_X1_X0_16_X4_X1_X1_X0_M14_g
+ N_X4_X1_X1_X0_14_X4_X1_X1_X0_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M15 N_X4_X1_X1_X0_15_X4_X1_X1_X0_M15_d N_CLK_X4_X1_X1_X0_M15_g
+ N_VDD_X4_X1_X1_X0_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M16 N_VDD_X4_X1_X1_X0_M16_d N_X4_X1_X1_X0_7_X4_X1_X1_X0_M16_g
+ N_X4_X1_X1_X0_10_X4_X1_X1_X0_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M17 N_X4_X1_X1_X0_7_X4_X1_X1_X0_M17_d
+ N_X4_X1_X1_X0_10_X4_X1_X1_X0_M17_g N_VDD_X4_X1_X1_X0_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M18 N_VDD_X4_X1_X1_X0_M18_d N_X4_X1_X1_X0_11_X4_X1_X1_X0_M18_g
+ N_X4_X1_32_X4_X1_X1_X0_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_M19 N_X4_X1_X1_X0_11_X4_X1_X1_X0_M19_d N_X4_X1_32_X4_X1_X1_X0_M19_g
+ N_VDD_X4_X1_X1_X0_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_X20_M0 N_X4_X1_X1_X0_16_X4_X1_X1_X0_X20_M0_d
+ N_X4_X1_X1_X0_X20_7_X4_X1_X1_X0_X20_M0_g N_X4_X1_32_X4_X1_X1_X0_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_X20_M1 N_4_X4_X1_X1_X0_X20_M1_d N_X4_X1_24_X4_X1_X1_X0_X20_M1_g
+ N_X4_X1_X1_X0_16_X4_X1_X1_X0_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_X20_M2 N_X4_X1_X1_X0_X20_7_X4_X1_X1_X0_X20_M2_d
+ N_X4_X1_24_X4_X1_X1_X0_X20_M2_g N_GROUND_X4_X1_X1_X0_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X0_X20_M3 N_X4_X1_X1_X0_16_X4_X1_X1_X0_X20_M3_d
+ N_X4_X1_24_X4_X1_X1_X0_X20_M3_g N_X4_X1_32_X4_X1_X1_X0_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X1_X0_X20_M4 N_4_X4_X1_X1_X0_X20_M4_d
+ N_X4_X1_X1_X0_X20_7_X4_X1_X1_X0_X20_M4_g N_X4_X1_X1_X0_16_X4_X1_X1_X0_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X1_X0_X20_M5 N_X4_X1_X1_X0_X20_7_X4_X1_X1_X0_X20_M5_d
+ N_X4_X1_24_X4_X1_X1_X0_X20_M5_g N_VDD_X4_X1_X1_X0_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX4_X1_X1_X1_M0 N_GROUND_X4_X1_X1_X1_M0_d N_X4_X1_X1_X1_11_X4_X1_X1_X1_M0_g
+ N_X4_X1_33_X4_X1_X1_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M1 N_X4_X1_X1_X1_7_X4_X1_X1_X1_M1_d
+ N_X4_X1_X1_X1_10_X4_X1_X1_X1_M1_g N_GROUND_X4_X1_X1_X1_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M2 X4_X1_X1_X1_8 N_X4_X1_X1_X1_15_X4_X1_X1_X1_M2_g
+ N_X4_X1_X1_X1_7_X4_X1_X1_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M3 N_GROUND_X4_X1_X1_X1_M3_d N_X4_X1_X1_X1_16_X4_X1_X1_X1_M3_g
+ X4_X1_X1_X1_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M4 X4_X1_X1_X1_9 N_X4_X1_X1_X1_14_X4_X1_X1_X1_M4_g
+ N_GROUND_X4_X1_X1_X1_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M5 N_X4_X1_X1_X1_10_X4_X1_X1_X1_M5_d
+ N_X4_X1_X1_X1_15_X4_X1_X1_X1_M5_g X4_X1_X1_X1_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M6 N_GROUND_X4_X1_X1_X1_M6_d N_X4_X1_X1_X1_7_X4_X1_X1_X1_M6_g
+ N_X4_X1_X1_X1_10_X4_X1_X1_X1_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M7 N_X4_X1_X1_X1_11_X4_X1_X1_X1_M7_d N_X4_X1_33_X4_X1_X1_X1_M7_g
+ N_GROUND_X4_X1_X1_X1_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M8 X4_X1_X1_X1_12 N_CLK_X4_X1_X1_X1_M8_g
+ N_X4_X1_X1_X1_11_X4_X1_X1_X1_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M9 N_GROUND_X4_X1_X1_X1_M9_d N_X4_X1_X1_X1_10_X4_X1_X1_X1_M9_g
+ X4_X1_X1_X1_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M10 X4_X1_X1_X1_13 N_X4_X1_X1_X1_7_X4_X1_X1_X1_M10_g
+ N_GROUND_X4_X1_X1_X1_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M11 N_X4_X1_33_X4_X1_X1_X1_M11_d N_CLK_X4_X1_X1_X1_M11_g
+ X4_X1_X1_X1_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M12 N_GROUND_X4_X1_X1_X1_M12_d N_X4_X1_X1_X1_16_X4_X1_X1_X1_M12_g
+ N_X4_X1_X1_X1_14_X4_X1_X1_X1_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M13 N_X4_X1_X1_X1_15_X4_X1_X1_X1_M13_d N_CLK_X4_X1_X1_X1_M13_g
+ N_GROUND_X4_X1_X1_X1_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M14 N_VDD_X4_X1_X1_X1_M14_d N_X4_X1_X1_X1_16_X4_X1_X1_X1_M14_g
+ N_X4_X1_X1_X1_14_X4_X1_X1_X1_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M15 N_X4_X1_X1_X1_15_X4_X1_X1_X1_M15_d N_CLK_X4_X1_X1_X1_M15_g
+ N_VDD_X4_X1_X1_X1_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M16 N_VDD_X4_X1_X1_X1_M16_d N_X4_X1_X1_X1_7_X4_X1_X1_X1_M16_g
+ N_X4_X1_X1_X1_10_X4_X1_X1_X1_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M17 N_X4_X1_X1_X1_7_X4_X1_X1_X1_M17_d
+ N_X4_X1_X1_X1_10_X4_X1_X1_X1_M17_g N_VDD_X4_X1_X1_X1_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M18 N_VDD_X4_X1_X1_X1_M18_d N_X4_X1_X1_X1_11_X4_X1_X1_X1_M18_g
+ N_X4_X1_33_X4_X1_X1_X1_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_M19 N_X4_X1_X1_X1_11_X4_X1_X1_X1_M19_d N_X4_X1_33_X4_X1_X1_X1_M19_g
+ N_VDD_X4_X1_X1_X1_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_X20_M0 N_X4_X1_X1_X1_16_X4_X1_X1_X1_X20_M0_d
+ N_X4_X1_X1_X1_X20_7_X4_X1_X1_X1_X20_M0_g N_X4_X1_33_X4_X1_X1_X1_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_X20_M1 N_4_X4_X1_X1_X1_X20_M1_d N_X4_X1_25_X4_X1_X1_X1_X20_M1_g
+ N_X4_X1_X1_X1_16_X4_X1_X1_X1_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_X20_M2 N_X4_X1_X1_X1_X20_7_X4_X1_X1_X1_X20_M2_d
+ N_X4_X1_25_X4_X1_X1_X1_X20_M2_g N_GROUND_X4_X1_X1_X1_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX4_X1_X1_X1_X20_M3 N_X4_X1_X1_X1_16_X4_X1_X1_X1_X20_M3_d
+ N_X4_X1_25_X4_X1_X1_X1_X20_M3_g N_X4_X1_33_X4_X1_X1_X1_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X1_X1_X20_M4 N_4_X4_X1_X1_X1_X20_M4_d
+ N_X4_X1_X1_X1_X20_7_X4_X1_X1_X1_X20_M4_g N_X4_X1_X1_X1_16_X4_X1_X1_X1_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X1_X1_X20_M5 N_X4_X1_X1_X1_X20_7_X4_X1_X1_X1_X20_M5_d
+ N_X4_X1_25_X4_X1_X1_X1_X20_M5_g N_VDD_X4_X1_X1_X1_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX4_X1_X2_X0_M0 N_GROUND_X4_X1_X2_X0_M0_d N_X4_X1_X2_X0_11_X4_X1_X2_X0_M0_g
+ N_X4_X1_34_X4_X1_X2_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M1 N_X4_X1_X2_X0_7_X4_X1_X2_X0_M1_d
+ N_X4_X1_X2_X0_10_X4_X1_X2_X0_M1_g N_GROUND_X4_X1_X2_X0_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M2 X4_X1_X2_X0_8 N_X4_X1_X2_X0_15_X4_X1_X2_X0_M2_g
+ N_X4_X1_X2_X0_7_X4_X1_X2_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M3 N_GROUND_X4_X1_X2_X0_M3_d N_X4_X1_X2_X0_16_X4_X1_X2_X0_M3_g
+ X4_X1_X2_X0_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M4 X4_X1_X2_X0_9 N_X4_X1_X2_X0_14_X4_X1_X2_X0_M4_g
+ N_GROUND_X4_X1_X2_X0_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M5 N_X4_X1_X2_X0_10_X4_X1_X2_X0_M5_d
+ N_X4_X1_X2_X0_15_X4_X1_X2_X0_M5_g X4_X1_X2_X0_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M6 N_GROUND_X4_X1_X2_X0_M6_d N_X4_X1_X2_X0_7_X4_X1_X2_X0_M6_g
+ N_X4_X1_X2_X0_10_X4_X1_X2_X0_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M7 N_X4_X1_X2_X0_11_X4_X1_X2_X0_M7_d N_X4_X1_34_X4_X1_X2_X0_M7_g
+ N_GROUND_X4_X1_X2_X0_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M8 X4_X1_X2_X0_12 N_CLK_X4_X1_X2_X0_M8_g
+ N_X4_X1_X2_X0_11_X4_X1_X2_X0_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M9 N_GROUND_X4_X1_X2_X0_M9_d N_X4_X1_X2_X0_10_X4_X1_X2_X0_M9_g
+ X4_X1_X2_X0_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M10 X4_X1_X2_X0_13 N_X4_X1_X2_X0_7_X4_X1_X2_X0_M10_g
+ N_GROUND_X4_X1_X2_X0_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M11 N_X4_X1_34_X4_X1_X2_X0_M11_d N_CLK_X4_X1_X2_X0_M11_g
+ X4_X1_X2_X0_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M12 N_GROUND_X4_X1_X2_X0_M12_d N_X4_X1_X2_X0_16_X4_X1_X2_X0_M12_g
+ N_X4_X1_X2_X0_14_X4_X1_X2_X0_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M13 N_X4_X1_X2_X0_15_X4_X1_X2_X0_M13_d N_CLK_X4_X1_X2_X0_M13_g
+ N_GROUND_X4_X1_X2_X0_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M14 N_VDD_X4_X1_X2_X0_M14_d N_X4_X1_X2_X0_16_X4_X1_X2_X0_M14_g
+ N_X4_X1_X2_X0_14_X4_X1_X2_X0_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M15 N_X4_X1_X2_X0_15_X4_X1_X2_X0_M15_d N_CLK_X4_X1_X2_X0_M15_g
+ N_VDD_X4_X1_X2_X0_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M16 N_VDD_X4_X1_X2_X0_M16_d N_X4_X1_X2_X0_7_X4_X1_X2_X0_M16_g
+ N_X4_X1_X2_X0_10_X4_X1_X2_X0_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M17 N_X4_X1_X2_X0_7_X4_X1_X2_X0_M17_d
+ N_X4_X1_X2_X0_10_X4_X1_X2_X0_M17_g N_VDD_X4_X1_X2_X0_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M18 N_VDD_X4_X1_X2_X0_M18_d N_X4_X1_X2_X0_11_X4_X1_X2_X0_M18_g
+ N_X4_X1_34_X4_X1_X2_X0_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_M19 N_X4_X1_X2_X0_11_X4_X1_X2_X0_M19_d N_X4_X1_34_X4_X1_X2_X0_M19_g
+ N_VDD_X4_X1_X2_X0_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_X20_M0 N_X4_X1_X2_X0_16_X4_X1_X2_X0_X20_M0_d
+ N_X4_X1_X2_X0_X20_7_X4_X1_X2_X0_X20_M0_g N_X4_X1_34_X4_X1_X2_X0_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_X20_M1 N_4_X4_X1_X2_X0_X20_M1_d N_X4_X1_26_X4_X1_X2_X0_X20_M1_g
+ N_X4_X1_X2_X0_16_X4_X1_X2_X0_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_X20_M2 N_X4_X1_X2_X0_X20_7_X4_X1_X2_X0_X20_M2_d
+ N_X4_X1_26_X4_X1_X2_X0_X20_M2_g N_GROUND_X4_X1_X2_X0_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X0_X20_M3 N_X4_X1_X2_X0_16_X4_X1_X2_X0_X20_M3_d
+ N_X4_X1_26_X4_X1_X2_X0_X20_M3_g N_X4_X1_34_X4_X1_X2_X0_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X2_X0_X20_M4 N_4_X4_X1_X2_X0_X20_M4_d
+ N_X4_X1_X2_X0_X20_7_X4_X1_X2_X0_X20_M4_g N_X4_X1_X2_X0_16_X4_X1_X2_X0_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X2_X0_X20_M5 N_X4_X1_X2_X0_X20_7_X4_X1_X2_X0_X20_M5_d
+ N_X4_X1_26_X4_X1_X2_X0_X20_M5_g N_VDD_X4_X1_X2_X0_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX4_X1_X2_X1_M0 N_GROUND_X4_X1_X2_X1_M0_d N_X4_X1_X2_X1_11_X4_X1_X2_X1_M0_g
+ N_X4_X1_35_X4_X1_X2_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M1 N_X4_X1_X2_X1_7_X4_X1_X2_X1_M1_d
+ N_X4_X1_X2_X1_10_X4_X1_X2_X1_M1_g N_GROUND_X4_X1_X2_X1_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M2 X4_X1_X2_X1_8 N_X4_X1_X2_X1_15_X4_X1_X2_X1_M2_g
+ N_X4_X1_X2_X1_7_X4_X1_X2_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M3 N_GROUND_X4_X1_X2_X1_M3_d N_X4_X1_X2_X1_16_X4_X1_X2_X1_M3_g
+ X4_X1_X2_X1_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M4 X4_X1_X2_X1_9 N_X4_X1_X2_X1_14_X4_X1_X2_X1_M4_g
+ N_GROUND_X4_X1_X2_X1_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M5 N_X4_X1_X2_X1_10_X4_X1_X2_X1_M5_d
+ N_X4_X1_X2_X1_15_X4_X1_X2_X1_M5_g X4_X1_X2_X1_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M6 N_GROUND_X4_X1_X2_X1_M6_d N_X4_X1_X2_X1_7_X4_X1_X2_X1_M6_g
+ N_X4_X1_X2_X1_10_X4_X1_X2_X1_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M7 N_X4_X1_X2_X1_11_X4_X1_X2_X1_M7_d N_X4_X1_35_X4_X1_X2_X1_M7_g
+ N_GROUND_X4_X1_X2_X1_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M8 X4_X1_X2_X1_12 N_CLK_X4_X1_X2_X1_M8_g
+ N_X4_X1_X2_X1_11_X4_X1_X2_X1_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M9 N_GROUND_X4_X1_X2_X1_M9_d N_X4_X1_X2_X1_10_X4_X1_X2_X1_M9_g
+ X4_X1_X2_X1_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M10 X4_X1_X2_X1_13 N_X4_X1_X2_X1_7_X4_X1_X2_X1_M10_g
+ N_GROUND_X4_X1_X2_X1_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M11 N_X4_X1_35_X4_X1_X2_X1_M11_d N_CLK_X4_X1_X2_X1_M11_g
+ X4_X1_X2_X1_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M12 N_GROUND_X4_X1_X2_X1_M12_d N_X4_X1_X2_X1_16_X4_X1_X2_X1_M12_g
+ N_X4_X1_X2_X1_14_X4_X1_X2_X1_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M13 N_X4_X1_X2_X1_15_X4_X1_X2_X1_M13_d N_CLK_X4_X1_X2_X1_M13_g
+ N_GROUND_X4_X1_X2_X1_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M14 N_VDD_X4_X1_X2_X1_M14_d N_X4_X1_X2_X1_16_X4_X1_X2_X1_M14_g
+ N_X4_X1_X2_X1_14_X4_X1_X2_X1_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M15 N_X4_X1_X2_X1_15_X4_X1_X2_X1_M15_d N_CLK_X4_X1_X2_X1_M15_g
+ N_VDD_X4_X1_X2_X1_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M16 N_VDD_X4_X1_X2_X1_M16_d N_X4_X1_X2_X1_7_X4_X1_X2_X1_M16_g
+ N_X4_X1_X2_X1_10_X4_X1_X2_X1_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M17 N_X4_X1_X2_X1_7_X4_X1_X2_X1_M17_d
+ N_X4_X1_X2_X1_10_X4_X1_X2_X1_M17_g N_VDD_X4_X1_X2_X1_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M18 N_VDD_X4_X1_X2_X1_M18_d N_X4_X1_X2_X1_11_X4_X1_X2_X1_M18_g
+ N_X4_X1_35_X4_X1_X2_X1_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_M19 N_X4_X1_X2_X1_11_X4_X1_X2_X1_M19_d N_X4_X1_35_X4_X1_X2_X1_M19_g
+ N_VDD_X4_X1_X2_X1_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_X20_M0 N_X4_X1_X2_X1_16_X4_X1_X2_X1_X20_M0_d
+ N_X4_X1_X2_X1_X20_7_X4_X1_X2_X1_X20_M0_g N_X4_X1_35_X4_X1_X2_X1_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_X20_M1 N_4_X4_X1_X2_X1_X20_M1_d N_X4_X1_27_X4_X1_X2_X1_X20_M1_g
+ N_X4_X1_X2_X1_16_X4_X1_X2_X1_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_X20_M2 N_X4_X1_X2_X1_X20_7_X4_X1_X2_X1_X20_M2_d
+ N_X4_X1_27_X4_X1_X2_X1_X20_M2_g N_GROUND_X4_X1_X2_X1_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX4_X1_X2_X1_X20_M3 N_X4_X1_X2_X1_16_X4_X1_X2_X1_X20_M3_d
+ N_X4_X1_27_X4_X1_X2_X1_X20_M3_g N_X4_X1_35_X4_X1_X2_X1_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X2_X1_X20_M4 N_4_X4_X1_X2_X1_X20_M4_d
+ N_X4_X1_X2_X1_X20_7_X4_X1_X2_X1_X20_M4_g N_X4_X1_X2_X1_16_X4_X1_X2_X1_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X2_X1_X20_M5 N_X4_X1_X2_X1_X20_7_X4_X1_X2_X1_X20_M5_d
+ N_X4_X1_27_X4_X1_X2_X1_X20_M5_g N_VDD_X4_X1_X2_X1_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX4_X1_X3_X0_M0 N_GROUND_X4_X1_X3_X0_M0_d N_X4_X1_X3_X0_11_X4_X1_X3_X0_M0_g
+ N_X4_X1_36_X4_X1_X3_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M1 N_X4_X1_X3_X0_7_X4_X1_X3_X0_M1_d
+ N_X4_X1_X3_X0_10_X4_X1_X3_X0_M1_g N_GROUND_X4_X1_X3_X0_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M2 X4_X1_X3_X0_8 N_X4_X1_X3_X0_15_X4_X1_X3_X0_M2_g
+ N_X4_X1_X3_X0_7_X4_X1_X3_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M3 N_GROUND_X4_X1_X3_X0_M3_d N_X4_X1_X3_X0_16_X4_X1_X3_X0_M3_g
+ X4_X1_X3_X0_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M4 X4_X1_X3_X0_9 N_X4_X1_X3_X0_14_X4_X1_X3_X0_M4_g
+ N_GROUND_X4_X1_X3_X0_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M5 N_X4_X1_X3_X0_10_X4_X1_X3_X0_M5_d
+ N_X4_X1_X3_X0_15_X4_X1_X3_X0_M5_g X4_X1_X3_X0_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M6 N_GROUND_X4_X1_X3_X0_M6_d N_X4_X1_X3_X0_7_X4_X1_X3_X0_M6_g
+ N_X4_X1_X3_X0_10_X4_X1_X3_X0_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M7 N_X4_X1_X3_X0_11_X4_X1_X3_X0_M7_d N_X4_X1_36_X4_X1_X3_X0_M7_g
+ N_GROUND_X4_X1_X3_X0_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M8 X4_X1_X3_X0_12 N_CLK_X4_X1_X3_X0_M8_g
+ N_X4_X1_X3_X0_11_X4_X1_X3_X0_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M9 N_GROUND_X4_X1_X3_X0_M9_d N_X4_X1_X3_X0_10_X4_X1_X3_X0_M9_g
+ X4_X1_X3_X0_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M10 X4_X1_X3_X0_13 N_X4_X1_X3_X0_7_X4_X1_X3_X0_M10_g
+ N_GROUND_X4_X1_X3_X0_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M11 N_X4_X1_36_X4_X1_X3_X0_M11_d N_CLK_X4_X1_X3_X0_M11_g
+ X4_X1_X3_X0_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M12 N_GROUND_X4_X1_X3_X0_M12_d N_X4_X1_X3_X0_16_X4_X1_X3_X0_M12_g
+ N_X4_X1_X3_X0_14_X4_X1_X3_X0_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M13 N_X4_X1_X3_X0_15_X4_X1_X3_X0_M13_d N_CLK_X4_X1_X3_X0_M13_g
+ N_GROUND_X4_X1_X3_X0_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M14 N_VDD_X4_X1_X3_X0_M14_d N_X4_X1_X3_X0_16_X4_X1_X3_X0_M14_g
+ N_X4_X1_X3_X0_14_X4_X1_X3_X0_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M15 N_X4_X1_X3_X0_15_X4_X1_X3_X0_M15_d N_CLK_X4_X1_X3_X0_M15_g
+ N_VDD_X4_X1_X3_X0_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M16 N_VDD_X4_X1_X3_X0_M16_d N_X4_X1_X3_X0_7_X4_X1_X3_X0_M16_g
+ N_X4_X1_X3_X0_10_X4_X1_X3_X0_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M17 N_X4_X1_X3_X0_7_X4_X1_X3_X0_M17_d
+ N_X4_X1_X3_X0_10_X4_X1_X3_X0_M17_g N_VDD_X4_X1_X3_X0_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M18 N_VDD_X4_X1_X3_X0_M18_d N_X4_X1_X3_X0_11_X4_X1_X3_X0_M18_g
+ N_X4_X1_36_X4_X1_X3_X0_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_M19 N_X4_X1_X3_X0_11_X4_X1_X3_X0_M19_d N_X4_X1_36_X4_X1_X3_X0_M19_g
+ N_VDD_X4_X1_X3_X0_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_X20_M0 N_X4_X1_X3_X0_16_X4_X1_X3_X0_X20_M0_d
+ N_X4_X1_X3_X0_X20_7_X4_X1_X3_X0_X20_M0_g N_X4_X1_36_X4_X1_X3_X0_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_X20_M1 N_4_X4_X1_X3_X0_X20_M1_d N_X4_X1_28_X4_X1_X3_X0_X20_M1_g
+ N_X4_X1_X3_X0_16_X4_X1_X3_X0_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_X20_M2 N_X4_X1_X3_X0_X20_7_X4_X1_X3_X0_X20_M2_d
+ N_X4_X1_28_X4_X1_X3_X0_X20_M2_g N_GROUND_X4_X1_X3_X0_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X0_X20_M3 N_X4_X1_X3_X0_16_X4_X1_X3_X0_X20_M3_d
+ N_X4_X1_28_X4_X1_X3_X0_X20_M3_g N_X4_X1_36_X4_X1_X3_X0_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X3_X0_X20_M4 N_4_X4_X1_X3_X0_X20_M4_d
+ N_X4_X1_X3_X0_X20_7_X4_X1_X3_X0_X20_M4_g N_X4_X1_X3_X0_16_X4_X1_X3_X0_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X3_X0_X20_M5 N_X4_X1_X3_X0_X20_7_X4_X1_X3_X0_X20_M5_d
+ N_X4_X1_28_X4_X1_X3_X0_X20_M5_g N_VDD_X4_X1_X3_X0_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX4_X1_X3_X1_M0 N_GROUND_X4_X1_X3_X1_M0_d N_X4_X1_X3_X1_11_X4_X1_X3_X1_M0_g
+ N_X4_X1_37_X4_X1_X3_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M1 N_X4_X1_X3_X1_7_X4_X1_X3_X1_M1_d
+ N_X4_X1_X3_X1_10_X4_X1_X3_X1_M1_g N_GROUND_X4_X1_X3_X1_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M2 X4_X1_X3_X1_8 N_X4_X1_X3_X1_15_X4_X1_X3_X1_M2_g
+ N_X4_X1_X3_X1_7_X4_X1_X3_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M3 N_GROUND_X4_X1_X3_X1_M3_d N_X4_X1_X3_X1_16_X4_X1_X3_X1_M3_g
+ X4_X1_X3_X1_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M4 X4_X1_X3_X1_9 N_X4_X1_X3_X1_14_X4_X1_X3_X1_M4_g
+ N_GROUND_X4_X1_X3_X1_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M5 N_X4_X1_X3_X1_10_X4_X1_X3_X1_M5_d
+ N_X4_X1_X3_X1_15_X4_X1_X3_X1_M5_g X4_X1_X3_X1_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M6 N_GROUND_X4_X1_X3_X1_M6_d N_X4_X1_X3_X1_7_X4_X1_X3_X1_M6_g
+ N_X4_X1_X3_X1_10_X4_X1_X3_X1_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M7 N_X4_X1_X3_X1_11_X4_X1_X3_X1_M7_d N_X4_X1_37_X4_X1_X3_X1_M7_g
+ N_GROUND_X4_X1_X3_X1_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M8 X4_X1_X3_X1_12 N_CLK_X4_X1_X3_X1_M8_g
+ N_X4_X1_X3_X1_11_X4_X1_X3_X1_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M9 N_GROUND_X4_X1_X3_X1_M9_d N_X4_X1_X3_X1_10_X4_X1_X3_X1_M9_g
+ X4_X1_X3_X1_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M10 X4_X1_X3_X1_13 N_X4_X1_X3_X1_7_X4_X1_X3_X1_M10_g
+ N_GROUND_X4_X1_X3_X1_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M11 N_X4_X1_37_X4_X1_X3_X1_M11_d N_CLK_X4_X1_X3_X1_M11_g
+ X4_X1_X3_X1_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M12 N_GROUND_X4_X1_X3_X1_M12_d N_X4_X1_X3_X1_16_X4_X1_X3_X1_M12_g
+ N_X4_X1_X3_X1_14_X4_X1_X3_X1_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M13 N_X4_X1_X3_X1_15_X4_X1_X3_X1_M13_d N_CLK_X4_X1_X3_X1_M13_g
+ N_GROUND_X4_X1_X3_X1_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M14 N_VDD_X4_X1_X3_X1_M14_d N_X4_X1_X3_X1_16_X4_X1_X3_X1_M14_g
+ N_X4_X1_X3_X1_14_X4_X1_X3_X1_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M15 N_X4_X1_X3_X1_15_X4_X1_X3_X1_M15_d N_CLK_X4_X1_X3_X1_M15_g
+ N_VDD_X4_X1_X3_X1_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M16 N_VDD_X4_X1_X3_X1_M16_d N_X4_X1_X3_X1_7_X4_X1_X3_X1_M16_g
+ N_X4_X1_X3_X1_10_X4_X1_X3_X1_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M17 N_X4_X1_X3_X1_7_X4_X1_X3_X1_M17_d
+ N_X4_X1_X3_X1_10_X4_X1_X3_X1_M17_g N_VDD_X4_X1_X3_X1_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M18 N_VDD_X4_X1_X3_X1_M18_d N_X4_X1_X3_X1_11_X4_X1_X3_X1_M18_g
+ N_X4_X1_37_X4_X1_X3_X1_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_M19 N_X4_X1_X3_X1_11_X4_X1_X3_X1_M19_d N_X4_X1_37_X4_X1_X3_X1_M19_g
+ N_VDD_X4_X1_X3_X1_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_X20_M0 N_X4_X1_X3_X1_16_X4_X1_X3_X1_X20_M0_d
+ N_X4_X1_X3_X1_X20_7_X4_X1_X3_X1_X20_M0_g N_X4_X1_37_X4_X1_X3_X1_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_X20_M1 N_4_X4_X1_X3_X1_X20_M1_d N_X4_X1_29_X4_X1_X3_X1_X20_M1_g
+ N_X4_X1_X3_X1_16_X4_X1_X3_X1_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_X20_M2 N_X4_X1_X3_X1_X20_7_X4_X1_X3_X1_X20_M2_d
+ N_X4_X1_29_X4_X1_X3_X1_X20_M2_g N_GROUND_X4_X1_X3_X1_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX4_X1_X3_X1_X20_M3 N_X4_X1_X3_X1_16_X4_X1_X3_X1_X20_M3_d
+ N_X4_X1_29_X4_X1_X3_X1_X20_M3_g N_X4_X1_37_X4_X1_X3_X1_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X3_X1_X20_M4 N_4_X4_X1_X3_X1_X20_M4_d
+ N_X4_X1_X3_X1_X20_7_X4_X1_X3_X1_X20_M4_g N_X4_X1_X3_X1_16_X4_X1_X3_X1_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X3_X1_X20_M5 N_X4_X1_X3_X1_X20_7_X4_X1_X3_X1_X20_M5_d
+ N_X4_X1_29_X4_X1_X3_X1_X20_M5_g N_VDD_X4_X1_X3_X1_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX4_X1_X4_X0_M0 X4_X1_X4_X0_7 N_19_X4_X1_X4_X0_M0_g
+ N_X4_X1_X4_X0_6_X4_X1_X4_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX4_X1_X4_X0_M1 N_GROUND_X4_X1_X4_X0_M1_d N_34_X4_X1_X4_X0_M1_g X4_X1_X4_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX4_X1_X4_X0_M2 N_X4_X1_22_X4_X1_X4_X0_M2_d N_X4_X1_X4_X0_6_X4_X1_X4_X0_M2_g
+ N_GROUND_X4_X1_X4_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X4_X0_M3 N_X4_X1_X4_X0_6_X4_X1_X4_X0_M3_d N_19_X4_X1_X4_X0_M3_g
+ N_VDD_X4_X1_X4_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X4_X0_M4 N_VDD_X4_X1_X4_X0_M4_d N_34_X4_X1_X4_X0_M4_g
+ N_X4_X1_X4_X0_6_X4_X1_X4_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X4_X0_M5 N_X4_X1_22_X4_X1_X4_X0_M5_d N_X4_X1_X4_X0_6_X4_X1_X4_X0_M5_g
+ N_VDD_X4_X1_X4_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X4_X1_M0 X4_X1_X4_X1_7 N_20_X4_X1_X4_X1_M0_g
+ N_X4_X1_X4_X1_6_X4_X1_X4_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX4_X1_X4_X1_M1 N_GROUND_X4_X1_X4_X1_M1_d N_34_X4_X1_X4_X1_M1_g X4_X1_X4_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX4_X1_X4_X1_M2 N_X4_X1_23_X4_X1_X4_X1_M2_d N_X4_X1_X4_X1_6_X4_X1_X4_X1_M2_g
+ N_GROUND_X4_X1_X4_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X4_X1_M3 N_X4_X1_X4_X1_6_X4_X1_X4_X1_M3_d N_20_X4_X1_X4_X1_M3_g
+ N_VDD_X4_X1_X4_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X4_X1_M4 N_VDD_X4_X1_X4_X1_M4_d N_34_X4_X1_X4_X1_M4_g
+ N_X4_X1_X4_X1_6_X4_X1_X4_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X4_X1_M5 N_X4_X1_23_X4_X1_X4_X1_M5_d N_X4_X1_X4_X1_6_X4_X1_X4_X1_M5_g
+ N_VDD_X4_X1_X4_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X5_X0_M0 X4_X1_X5_X0_7 N_21_X4_X1_X5_X0_M0_g
+ N_X4_X1_X5_X0_6_X4_X1_X5_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX4_X1_X5_X0_M1 N_GROUND_X4_X1_X5_X0_M1_d N_34_X4_X1_X5_X0_M1_g X4_X1_X5_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX4_X1_X5_X0_M2 N_X4_X1_24_X4_X1_X5_X0_M2_d N_X4_X1_X5_X0_6_X4_X1_X5_X0_M2_g
+ N_GROUND_X4_X1_X5_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X5_X0_M3 N_X4_X1_X5_X0_6_X4_X1_X5_X0_M3_d N_21_X4_X1_X5_X0_M3_g
+ N_VDD_X4_X1_X5_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X5_X0_M4 N_VDD_X4_X1_X5_X0_M4_d N_34_X4_X1_X5_X0_M4_g
+ N_X4_X1_X5_X0_6_X4_X1_X5_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X5_X0_M5 N_X4_X1_24_X4_X1_X5_X0_M5_d N_X4_X1_X5_X0_6_X4_X1_X5_X0_M5_g
+ N_VDD_X4_X1_X5_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X5_X1_M0 X4_X1_X5_X1_7 N_22_X4_X1_X5_X1_M0_g
+ N_X4_X1_X5_X1_6_X4_X1_X5_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX4_X1_X5_X1_M1 N_GROUND_X4_X1_X5_X1_M1_d N_34_X4_X1_X5_X1_M1_g X4_X1_X5_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX4_X1_X5_X1_M2 N_X4_X1_25_X4_X1_X5_X1_M2_d N_X4_X1_X5_X1_6_X4_X1_X5_X1_M2_g
+ N_GROUND_X4_X1_X5_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X5_X1_M3 N_X4_X1_X5_X1_6_X4_X1_X5_X1_M3_d N_22_X4_X1_X5_X1_M3_g
+ N_VDD_X4_X1_X5_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X5_X1_M4 N_VDD_X4_X1_X5_X1_M4_d N_34_X4_X1_X5_X1_M4_g
+ N_X4_X1_X5_X1_6_X4_X1_X5_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X5_X1_M5 N_X4_X1_25_X4_X1_X5_X1_M5_d N_X4_X1_X5_X1_6_X4_X1_X5_X1_M5_g
+ N_VDD_X4_X1_X5_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X6_X0_M0 X4_X1_X6_X0_7 N_23_X4_X1_X6_X0_M0_g
+ N_X4_X1_X6_X0_6_X4_X1_X6_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX4_X1_X6_X0_M1 N_GROUND_X4_X1_X6_X0_M1_d N_34_X4_X1_X6_X0_M1_g X4_X1_X6_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX4_X1_X6_X0_M2 N_X4_X1_26_X4_X1_X6_X0_M2_d N_X4_X1_X6_X0_6_X4_X1_X6_X0_M2_g
+ N_GROUND_X4_X1_X6_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X6_X0_M3 N_X4_X1_X6_X0_6_X4_X1_X6_X0_M3_d N_23_X4_X1_X6_X0_M3_g
+ N_VDD_X4_X1_X6_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X6_X0_M4 N_VDD_X4_X1_X6_X0_M4_d N_34_X4_X1_X6_X0_M4_g
+ N_X4_X1_X6_X0_6_X4_X1_X6_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X6_X0_M5 N_X4_X1_26_X4_X1_X6_X0_M5_d N_X4_X1_X6_X0_6_X4_X1_X6_X0_M5_g
+ N_VDD_X4_X1_X6_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X6_X1_M0 X4_X1_X6_X1_7 N_24_X4_X1_X6_X1_M0_g
+ N_X4_X1_X6_X1_6_X4_X1_X6_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX4_X1_X6_X1_M1 N_GROUND_X4_X1_X6_X1_M1_d N_34_X4_X1_X6_X1_M1_g X4_X1_X6_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX4_X1_X6_X1_M2 N_X4_X1_27_X4_X1_X6_X1_M2_d N_X4_X1_X6_X1_6_X4_X1_X6_X1_M2_g
+ N_GROUND_X4_X1_X6_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X6_X1_M3 N_X4_X1_X6_X1_6_X4_X1_X6_X1_M3_d N_24_X4_X1_X6_X1_M3_g
+ N_VDD_X4_X1_X6_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X6_X1_M4 N_VDD_X4_X1_X6_X1_M4_d N_34_X4_X1_X6_X1_M4_g
+ N_X4_X1_X6_X1_6_X4_X1_X6_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X6_X1_M5 N_X4_X1_27_X4_X1_X6_X1_M5_d N_X4_X1_X6_X1_6_X4_X1_X6_X1_M5_g
+ N_VDD_X4_X1_X6_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X7_X0_M0 X4_X1_X7_X0_7 N_25_X4_X1_X7_X0_M0_g
+ N_X4_X1_X7_X0_6_X4_X1_X7_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX4_X1_X7_X0_M1 N_GROUND_X4_X1_X7_X0_M1_d N_34_X4_X1_X7_X0_M1_g X4_X1_X7_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX4_X1_X7_X0_M2 N_X4_X1_28_X4_X1_X7_X0_M2_d N_X4_X1_X7_X0_6_X4_X1_X7_X0_M2_g
+ N_GROUND_X4_X1_X7_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X7_X0_M3 N_X4_X1_X7_X0_6_X4_X1_X7_X0_M3_d N_25_X4_X1_X7_X0_M3_g
+ N_VDD_X4_X1_X7_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X7_X0_M4 N_VDD_X4_X1_X7_X0_M4_d N_34_X4_X1_X7_X0_M4_g
+ N_X4_X1_X7_X0_6_X4_X1_X7_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X7_X0_M5 N_X4_X1_28_X4_X1_X7_X0_M5_d N_X4_X1_X7_X0_6_X4_X1_X7_X0_M5_g
+ N_VDD_X4_X1_X7_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X7_X1_M0 X4_X1_X7_X1_7 N_26_X4_X1_X7_X1_M0_g
+ N_X4_X1_X7_X1_6_X4_X1_X7_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX4_X1_X7_X1_M1 N_GROUND_X4_X1_X7_X1_M1_d N_34_X4_X1_X7_X1_M1_g X4_X1_X7_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX4_X1_X7_X1_M2 N_X4_X1_29_X4_X1_X7_X1_M2_d N_X4_X1_X7_X1_6_X4_X1_X7_X1_M2_g
+ N_GROUND_X4_X1_X7_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X7_X1_M3 N_X4_X1_X7_X1_6_X4_X1_X7_X1_M3_d N_26_X4_X1_X7_X1_M3_g
+ N_VDD_X4_X1_X7_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X7_X1_M4 N_VDD_X4_X1_X7_X1_M4_d N_34_X4_X1_X7_X1_M4_g
+ N_X4_X1_X7_X1_6_X4_X1_X7_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X7_X1_M5 N_X4_X1_29_X4_X1_X7_X1_M5_d N_X4_X1_X7_X1_6_X4_X1_X7_X1_M5_g
+ N_VDD_X4_X1_X7_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X0_M0 N_X4_X1_X8_15_X4_X1_X8_X0_M0_d N_X4_X1_X8_X0_7_X4_X1_X8_X0_M0_g
+ N_X4_X1_30_X4_X1_X8_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X0_M1 N_X4_X1_31_X4_X1_X8_X0_M1_d N_RS0_X4_X1_X8_X0_M1_g
+ N_X4_X1_X8_15_X4_X1_X8_X0_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X0_M2 N_X4_X1_X8_X0_7_X4_X1_X8_X0_M2_d N_RS0_X4_X1_X8_X0_M2_g
+ N_GROUND_X4_X1_X8_X0_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X0_M3 N_X4_X1_X8_15_X4_X1_X8_X0_M3_d N_RS0_X4_X1_X8_X0_M3_g
+ N_X4_X1_30_X4_X1_X8_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X0_M4 N_X4_X1_31_X4_X1_X8_X0_M4_d N_X4_X1_X8_X0_7_X4_X1_X8_X0_M4_g
+ N_X4_X1_X8_15_X4_X1_X8_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X0_M5 N_X4_X1_X8_X0_7_X4_X1_X8_X0_M5_d N_RS0_X4_X1_X8_X0_M5_g
+ N_VDD_X4_X1_X8_X0_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X1_M0 N_X4_X1_X8_16_X4_X1_X8_X1_M0_d N_X4_X1_X8_X1_7_X4_X1_X8_X1_M0_g
+ N_X4_X1_32_X4_X1_X8_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X1_M1 N_X4_X1_33_X4_X1_X8_X1_M1_d N_RS0_X4_X1_X8_X1_M1_g
+ N_X4_X1_X8_16_X4_X1_X8_X1_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X1_M2 N_X4_X1_X8_X1_7_X4_X1_X8_X1_M2_d N_RS0_X4_X1_X8_X1_M2_g
+ N_GROUND_X4_X1_X8_X1_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X1_M3 N_X4_X1_X8_16_X4_X1_X8_X1_M3_d N_RS0_X4_X1_X8_X1_M3_g
+ N_X4_X1_32_X4_X1_X8_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X1_M4 N_X4_X1_33_X4_X1_X8_X1_M4_d N_X4_X1_X8_X1_7_X4_X1_X8_X1_M4_g
+ N_X4_X1_X8_16_X4_X1_X8_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X1_M5 N_X4_X1_X8_X1_7_X4_X1_X8_X1_M5_d N_RS0_X4_X1_X8_X1_M5_g
+ N_VDD_X4_X1_X8_X1_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X2_M0 N_X4_X1_X8_19_X4_X1_X8_X2_M0_d N_X4_X1_X8_X2_7_X4_X1_X8_X2_M0_g
+ N_X4_X1_X8_15_X4_X1_X8_X2_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X2_M1 N_X4_X1_X8_16_X4_X1_X8_X2_M1_d N_RS1_X4_X1_X8_X2_M1_g
+ N_X4_X1_X8_19_X4_X1_X8_X2_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X2_M2 N_X4_X1_X8_X2_7_X4_X1_X8_X2_M2_d N_RS1_X4_X1_X8_X2_M2_g
+ N_GROUND_X4_X1_X8_X2_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X2_M3 N_X4_X1_X8_19_X4_X1_X8_X2_M3_d N_RS1_X4_X1_X8_X2_M3_g
+ N_X4_X1_X8_15_X4_X1_X8_X2_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X2_M4 N_X4_X1_X8_16_X4_X1_X8_X2_M4_d N_X4_X1_X8_X2_7_X4_X1_X8_X2_M4_g
+ N_X4_X1_X8_19_X4_X1_X8_X2_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X2_M5 N_X4_X1_X8_X2_7_X4_X1_X8_X2_M5_d N_RS1_X4_X1_X8_X2_M5_g
+ N_VDD_X4_X1_X8_X2_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X3_M0 N_X4_X1_X8_17_X4_X1_X8_X3_M0_d N_X4_X1_X8_X3_7_X4_X1_X8_X3_M0_g
+ N_X4_X1_34_X4_X1_X8_X3_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X3_M1 N_X4_X1_35_X4_X1_X8_X3_M1_d N_RS0_X4_X1_X8_X3_M1_g
+ N_X4_X1_X8_17_X4_X1_X8_X3_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X3_M2 N_X4_X1_X8_X3_7_X4_X1_X8_X3_M2_d N_RS0_X4_X1_X8_X3_M2_g
+ N_GROUND_X4_X1_X8_X3_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X3_M3 N_X4_X1_X8_17_X4_X1_X8_X3_M3_d N_RS0_X4_X1_X8_X3_M3_g
+ N_X4_X1_34_X4_X1_X8_X3_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X3_M4 N_X4_X1_35_X4_X1_X8_X3_M4_d N_X4_X1_X8_X3_7_X4_X1_X8_X3_M4_g
+ N_X4_X1_X8_17_X4_X1_X8_X3_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X3_M5 N_X4_X1_X8_X3_7_X4_X1_X8_X3_M5_d N_RS0_X4_X1_X8_X3_M5_g
+ N_VDD_X4_X1_X8_X3_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X4_M0 N_X4_X1_X8_18_X4_X1_X8_X4_M0_d N_X4_X1_X8_X4_7_X4_X1_X8_X4_M0_g
+ N_X4_X1_36_X4_X1_X8_X4_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X4_M1 N_X4_X1_37_X4_X1_X8_X4_M1_d N_RS0_X4_X1_X8_X4_M1_g
+ N_X4_X1_X8_18_X4_X1_X8_X4_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X4_M2 N_X4_X1_X8_X4_7_X4_X1_X8_X4_M2_d N_RS0_X4_X1_X8_X4_M2_g
+ N_GROUND_X4_X1_X8_X4_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X4_M3 N_X4_X1_X8_18_X4_X1_X8_X4_M3_d N_RS0_X4_X1_X8_X4_M3_g
+ N_X4_X1_36_X4_X1_X8_X4_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X4_M4 N_X4_X1_37_X4_X1_X8_X4_M4_d N_X4_X1_X8_X4_7_X4_X1_X8_X4_M4_g
+ N_X4_X1_X8_18_X4_X1_X8_X4_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X4_M5 N_X4_X1_X8_X4_7_X4_X1_X8_X4_M5_d N_RS0_X4_X1_X8_X4_M5_g
+ N_VDD_X4_X1_X8_X4_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X5_M0 N_X4_X1_X8_20_X4_X1_X8_X5_M0_d N_X4_X1_X8_X5_7_X4_X1_X8_X5_M0_g
+ N_X4_X1_X8_17_X4_X1_X8_X5_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X5_M1 N_X4_X1_X8_18_X4_X1_X8_X5_M1_d N_RS1_X4_X1_X8_X5_M1_g
+ N_X4_X1_X8_20_X4_X1_X8_X5_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X5_M2 N_X4_X1_X8_X5_7_X4_X1_X8_X5_M2_d N_RS1_X4_X1_X8_X5_M2_g
+ N_GROUND_X4_X1_X8_X5_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X5_M3 N_X4_X1_X8_20_X4_X1_X8_X5_M3_d N_RS1_X4_X1_X8_X5_M3_g
+ N_X4_X1_X8_17_X4_X1_X8_X5_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X5_M4 N_X4_X1_X8_18_X4_X1_X8_X5_M4_d N_X4_X1_X8_X5_7_X4_X1_X8_X5_M4_g
+ N_X4_X1_X8_20_X4_X1_X8_X5_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X5_M5 N_X4_X1_X8_X5_7_X4_X1_X8_X5_M5_d N_RS1_X4_X1_X8_X5_M5_g
+ N_VDD_X4_X1_X8_X5_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X6_M0 N_X4_47_X4_X1_X8_X6_M0_d N_X4_X1_X8_X6_7_X4_X1_X8_X6_M0_g
+ N_X4_X1_X8_19_X4_X1_X8_X6_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X6_M1 N_X4_X1_X8_20_X4_X1_X8_X6_M1_d N_RS2_X4_X1_X8_X6_M1_g
+ N_X4_47_X4_X1_X8_X6_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X6_M2 N_X4_X1_X8_X6_7_X4_X1_X8_X6_M2_d N_RS2_X4_X1_X8_X6_M2_g
+ N_GROUND_X4_X1_X8_X6_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X8_X6_M3 N_X4_47_X4_X1_X8_X6_M3_d N_RS2_X4_X1_X8_X6_M3_g
+ N_X4_X1_X8_19_X4_X1_X8_X6_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X6_M4 N_X4_X1_X8_20_X4_X1_X8_X6_M4_d N_X4_X1_X8_X6_7_X4_X1_X8_X6_M4_g
+ N_X4_47_X4_X1_X8_X6_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X8_X6_M5 N_X4_X1_X8_X6_7_X4_X1_X8_X6_M5_d N_RS2_X4_X1_X8_X6_M5_g
+ N_VDD_X4_X1_X8_X6_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X0_M0 N_X4_X1_X9_15_X4_X1_X9_X0_M0_d N_X4_X1_X9_X0_7_X4_X1_X9_X0_M0_g
+ N_X4_X1_30_X4_X1_X9_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X0_M1 N_X4_X1_31_X4_X1_X9_X0_M1_d N_RT0_X4_X1_X9_X0_M1_g
+ N_X4_X1_X9_15_X4_X1_X9_X0_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X0_M2 N_X4_X1_X9_X0_7_X4_X1_X9_X0_M2_d N_RT0_X4_X1_X9_X0_M2_g
+ N_GROUND_X4_X1_X9_X0_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X0_M3 N_X4_X1_X9_15_X4_X1_X9_X0_M3_d N_RT0_X4_X1_X9_X0_M3_g
+ N_X4_X1_30_X4_X1_X9_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X0_M4 N_X4_X1_31_X4_X1_X9_X0_M4_d N_X4_X1_X9_X0_7_X4_X1_X9_X0_M4_g
+ N_X4_X1_X9_15_X4_X1_X9_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X0_M5 N_X4_X1_X9_X0_7_X4_X1_X9_X0_M5_d N_RT0_X4_X1_X9_X0_M5_g
+ N_VDD_X4_X1_X9_X0_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X1_M0 N_X4_X1_X9_16_X4_X1_X9_X1_M0_d N_X4_X1_X9_X1_7_X4_X1_X9_X1_M0_g
+ N_X4_X1_32_X4_X1_X9_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X1_M1 N_X4_X1_33_X4_X1_X9_X1_M1_d N_RT0_X4_X1_X9_X1_M1_g
+ N_X4_X1_X9_16_X4_X1_X9_X1_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X1_M2 N_X4_X1_X9_X1_7_X4_X1_X9_X1_M2_d N_RT0_X4_X1_X9_X1_M2_g
+ N_GROUND_X4_X1_X9_X1_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X1_M3 N_X4_X1_X9_16_X4_X1_X9_X1_M3_d N_RT0_X4_X1_X9_X1_M3_g
+ N_X4_X1_32_X4_X1_X9_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X1_M4 N_X4_X1_33_X4_X1_X9_X1_M4_d N_X4_X1_X9_X1_7_X4_X1_X9_X1_M4_g
+ N_X4_X1_X9_16_X4_X1_X9_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X1_M5 N_X4_X1_X9_X1_7_X4_X1_X9_X1_M5_d N_RT0_X4_X1_X9_X1_M5_g
+ N_VDD_X4_X1_X9_X1_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X2_M0 N_X4_X1_X9_19_X4_X1_X9_X2_M0_d N_X4_X1_X9_X2_7_X4_X1_X9_X2_M0_g
+ N_X4_X1_X9_15_X4_X1_X9_X2_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X2_M1 N_X4_X1_X9_16_X4_X1_X9_X2_M1_d N_RT1_X4_X1_X9_X2_M1_g
+ N_X4_X1_X9_19_X4_X1_X9_X2_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X2_M2 N_X4_X1_X9_X2_7_X4_X1_X9_X2_M2_d N_RT1_X4_X1_X9_X2_M2_g
+ N_GROUND_X4_X1_X9_X2_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X2_M3 N_X4_X1_X9_19_X4_X1_X9_X2_M3_d N_RT1_X4_X1_X9_X2_M3_g
+ N_X4_X1_X9_15_X4_X1_X9_X2_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X2_M4 N_X4_X1_X9_16_X4_X1_X9_X2_M4_d N_X4_X1_X9_X2_7_X4_X1_X9_X2_M4_g
+ N_X4_X1_X9_19_X4_X1_X9_X2_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X2_M5 N_X4_X1_X9_X2_7_X4_X1_X9_X2_M5_d N_RT1_X4_X1_X9_X2_M5_g
+ N_VDD_X4_X1_X9_X2_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X3_M0 N_X4_X1_X9_17_X4_X1_X9_X3_M0_d N_X4_X1_X9_X3_7_X4_X1_X9_X3_M0_g
+ N_X4_X1_34_X4_X1_X9_X3_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X3_M1 N_X4_X1_35_X4_X1_X9_X3_M1_d N_RT0_X4_X1_X9_X3_M1_g
+ N_X4_X1_X9_17_X4_X1_X9_X3_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X3_M2 N_X4_X1_X9_X3_7_X4_X1_X9_X3_M2_d N_RT0_X4_X1_X9_X3_M2_g
+ N_GROUND_X4_X1_X9_X3_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X3_M3 N_X4_X1_X9_17_X4_X1_X9_X3_M3_d N_RT0_X4_X1_X9_X3_M3_g
+ N_X4_X1_34_X4_X1_X9_X3_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X3_M4 N_X4_X1_35_X4_X1_X9_X3_M4_d N_X4_X1_X9_X3_7_X4_X1_X9_X3_M4_g
+ N_X4_X1_X9_17_X4_X1_X9_X3_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X3_M5 N_X4_X1_X9_X3_7_X4_X1_X9_X3_M5_d N_RT0_X4_X1_X9_X3_M5_g
+ N_VDD_X4_X1_X9_X3_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X4_M0 N_X4_X1_X9_18_X4_X1_X9_X4_M0_d N_X4_X1_X9_X4_7_X4_X1_X9_X4_M0_g
+ N_X4_X1_36_X4_X1_X9_X4_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X4_M1 N_X4_X1_37_X4_X1_X9_X4_M1_d N_RT0_X4_X1_X9_X4_M1_g
+ N_X4_X1_X9_18_X4_X1_X9_X4_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X4_M2 N_X4_X1_X9_X4_7_X4_X1_X9_X4_M2_d N_RT0_X4_X1_X9_X4_M2_g
+ N_GROUND_X4_X1_X9_X4_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X4_M3 N_X4_X1_X9_18_X4_X1_X9_X4_M3_d N_RT0_X4_X1_X9_X4_M3_g
+ N_X4_X1_36_X4_X1_X9_X4_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X4_M4 N_X4_X1_37_X4_X1_X9_X4_M4_d N_X4_X1_X9_X4_7_X4_X1_X9_X4_M4_g
+ N_X4_X1_X9_18_X4_X1_X9_X4_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X4_M5 N_X4_X1_X9_X4_7_X4_X1_X9_X4_M5_d N_RT0_X4_X1_X9_X4_M5_g
+ N_VDD_X4_X1_X9_X4_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X5_M0 N_X4_X1_X9_20_X4_X1_X9_X5_M0_d N_X4_X1_X9_X5_7_X4_X1_X9_X5_M0_g
+ N_X4_X1_X9_17_X4_X1_X9_X5_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X5_M1 N_X4_X1_X9_18_X4_X1_X9_X5_M1_d N_RT1_X4_X1_X9_X5_M1_g
+ N_X4_X1_X9_20_X4_X1_X9_X5_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X5_M2 N_X4_X1_X9_X5_7_X4_X1_X9_X5_M2_d N_RT1_X4_X1_X9_X5_M2_g
+ N_GROUND_X4_X1_X9_X5_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X5_M3 N_X4_X1_X9_20_X4_X1_X9_X5_M3_d N_RT1_X4_X1_X9_X5_M3_g
+ N_X4_X1_X9_17_X4_X1_X9_X5_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X5_M4 N_X4_X1_X9_18_X4_X1_X9_X5_M4_d N_X4_X1_X9_X5_7_X4_X1_X9_X5_M4_g
+ N_X4_X1_X9_20_X4_X1_X9_X5_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X5_M5 N_X4_X1_X9_X5_7_X4_X1_X9_X5_M5_d N_RT1_X4_X1_X9_X5_M5_g
+ N_VDD_X4_X1_X9_X5_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X6_M0 N_X4_48_X4_X1_X9_X6_M0_d N_X4_X1_X9_X6_7_X4_X1_X9_X6_M0_g
+ N_X4_X1_X9_19_X4_X1_X9_X6_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X6_M1 N_X4_X1_X9_20_X4_X1_X9_X6_M1_d N_RT2_X4_X1_X9_X6_M1_g
+ N_X4_48_X4_X1_X9_X6_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X6_M2 N_X4_X1_X9_X6_7_X4_X1_X9_X6_M2_d N_RT2_X4_X1_X9_X6_M2_g
+ N_GROUND_X4_X1_X9_X6_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX4_X1_X9_X6_M3 N_X4_48_X4_X1_X9_X6_M3_d N_RT2_X4_X1_X9_X6_M3_g
+ N_X4_X1_X9_19_X4_X1_X9_X6_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X6_M4 N_X4_X1_X9_20_X4_X1_X9_X6_M4_d N_X4_X1_X9_X6_7_X4_X1_X9_X6_M4_g
+ N_X4_48_X4_X1_X9_X6_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX4_X1_X9_X6_M5 N_X4_X1_X9_X6_7_X4_X1_X9_X6_M5_d N_RT2_X4_X1_X9_X6_M5_g
+ N_VDD_X4_X1_X9_X6_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_M0 X5_X0_11 N_29_X5_X0_M0_g N_X5_X0_10_X5_X0_M0_s N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=2e-06
mX5_X0_M1 X5_X0_12 N_X5_X0_23_X5_X0_M1_g X5_X0_11 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=2e-06
mX5_X0_M2 N_GROUND_X5_X0_M2_d N_X5_47_X5_X0_M2_g X5_X0_12 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=2e-06
mX5_X0_M3 N_39_X5_X0_M3_d N_X5_X0_16_X5_X0_M3_g N_GROUND_X5_X0_M2_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX5_X0_M4 N_GROUND_X5_X0_M4_d N_X5_X0_10_X5_X0_M4_g N_X5_X0_13_X5_X0_M4_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX5_X0_M5 N_X5_X0_14_X5_X0_M5_d N_29_X5_X0_M5_g N_GROUND_X5_X0_M4_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX5_X0_M6 N_GROUND_X5_X0_M6_d N_X5_X0_23_X5_X0_M6_g N_X5_X0_14_X5_X0_M5_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX5_X0_M7 N_X5_X0_14_X5_X0_M7_d N_X5_47_X5_X0_M7_g N_GROUND_X5_X0_M6_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX5_X0_M8 N_X5_X0_10_X5_X0_M8_d N_X5_X0_16_X5_X0_M8_g N_X5_X0_14_X5_X0_M7_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX5_X0_M9 N_X5_X0_15_X5_X0_M9_d N_X5_X0_23_X5_X0_M9_g N_GROUND_X5_X0_M9_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX5_X0_M10 N_X5_X0_16_X5_X0_M10_d N_29_X5_X0_M10_g N_X5_X0_15_X5_X0_M9_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX5_X0_M11 X5_X0_17 N_X5_47_X5_X0_M11_g N_X5_X0_16_X5_X0_M10_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=2e-06
mX5_X0_M12 N_GROUND_X5_X0_M12_d N_X5_X0_23_X5_X0_M12_g X5_X0_17 N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=2e-06
mX5_X0_M13 N_X5_X0_15_X5_X0_M13_d N_X5_47_X5_X0_M13_g N_GROUND_X5_X0_M12_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX5_X0_M14 N_X5_X0_16_X5_X0_M14_d N_29_X5_X0_M14_g N_X5_X0_18_X5_X0_M14_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX5_X0_M15 X5_X0_19 N_X5_47_X5_X0_M15_g N_X5_X0_16_X5_X0_M14_d N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=2e-06
mX5_X0_M16 N_VDD_X5_X0_M16_d N_X5_X0_23_X5_X0_M16_g X5_X0_19 N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=2e-06
mX5_X0_M17 N_X5_X0_18_X5_X0_M17_d N_X5_X0_23_X5_X0_M17_g N_VDD_X5_X0_M16_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX5_X0_M18 N_VDD_X5_X0_M18_d N_X5_47_X5_X0_M18_g N_X5_X0_18_X5_X0_M17_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX5_X0_M19 X5_X0_20 N_X5_47_X5_X0_M19_g N_VDD_X5_X0_M18_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=2e-06
mX5_X0_M20 X5_X0_21 N_X5_X0_23_X5_X0_M20_g X5_X0_20 N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=2e-06
mX5_X0_M21 N_X5_X0_10_X5_X0_M21_d N_29_X5_X0_M21_g X5_X0_21 N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=2e-06
mX5_X0_M22 N_X5_X0_22_X5_X0_M22_d N_X5_X0_16_X5_X0_M22_g N_X5_X0_10_X5_X0_M21_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX5_X0_M23 N_VDD_X5_X0_M23_d N_X5_X0_16_X5_X0_M23_g N_39_X5_X0_M23_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX5_X0_M24 N_X5_X0_22_X5_X0_M24_d N_X5_47_X5_X0_M24_g N_VDD_X5_X0_M23_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX5_X0_M25 N_VDD_X5_X0_M25_d N_X5_X0_23_X5_X0_M25_g N_X5_X0_22_X5_X0_M24_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX5_X0_M26 N_X5_X0_22_X5_X0_M26_d N_29_X5_X0_M26_g N_VDD_X5_X0_M25_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX5_X0_M27 N_X5_X0_13_X5_X0_M27_d N_X5_X0_10_X5_X0_M27_g N_VDD_X5_X0_M27_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX5_X0_X28_M0 N_X5_X0_X28_6_X5_X0_X28_M0_d N_X5_48_X5_X0_X28_M0_g
+ N_GROUND_X5_X0_X28_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_X28_M1 N_GROUND_X5_X0_X28_M1_d N_X5_47_X5_X0_X28_M1_g
+ N_X5_X0_X28_6_X5_X0_X28_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_X28_M2 N_X5_X0_24_X5_X0_X28_M2_d N_X5_X0_X28_6_X5_X0_X28_M2_g
+ N_GROUND_X5_X0_X28_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_X28_M3 N_VDD_X5_X0_X28_M3_d N_X5_X0_X28_6_X5_X0_X28_M3_g
+ N_X5_X0_24_X5_X0_X28_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_X28_M4 X5_X0_X28_7 N_X5_47_X5_X0_X28_M4_g N_VDD_X5_X0_X28_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX5_X0_X28_M5 N_X5_X0_X28_6_X5_X0_X28_M5_d N_X5_48_X5_X0_X28_M5_g X5_X0_X28_7
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX5_X0_X29_M0 N_X5_X0_25_X5_X0_X29_M0_d N_X5_48_X5_X0_X29_M0_g
+ N_GROUND_X5_X0_X29_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_X29_M1 N_X5_X0_25_X5_X0_X29_M1_d N_X5_48_X5_X0_X29_M1_g
+ N_VDD_X5_X0_X29_M1_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_X30_M0 N_X5_X0_23_X5_X0_X30_M0_d N_X5_X0_X30_7_X5_X0_X30_M0_g
+ N_X5_48_X5_X0_X30_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_X30_M1 N_X5_X0_25_X5_X0_X30_M1_d N_29_X5_X0_X30_M1_g
+ N_X5_X0_23_X5_X0_X30_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_X30_M2 N_X5_X0_X30_7_X5_X0_X30_M2_d N_29_X5_X0_X30_M2_g
+ N_GROUND_X5_X0_X30_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_X30_M3 N_X5_X0_23_X5_X0_X30_M3_d N_29_X5_X0_X30_M3_g
+ N_X5_48_X5_X0_X30_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_X30_M4 N_X5_X0_25_X5_X0_X30_M4_d N_X5_X0_X30_7_X5_X0_X30_M4_g
+ N_X5_X0_23_X5_X0_X30_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_X30_M5 N_X5_X0_X30_7_X5_X0_X30_M5_d N_29_X5_X0_X30_M5_g
+ N_VDD_X5_X0_X30_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_X31_M0 N_X5_X0_27_X5_X0_X31_M0_d N_X5_X0_X31_7_X5_X0_X31_M0_g
+ N_X5_X0_13_X5_X0_X31_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_X31_M1 N_X5_X0_13_X5_X0_X31_M1_d N_29_X5_X0_X31_M1_g
+ N_X5_X0_27_X5_X0_X31_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_X31_M2 N_X5_X0_X31_7_X5_X0_X31_M2_d N_29_X5_X0_X31_M2_g
+ N_GROUND_X5_X0_X31_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_X31_M3 N_X5_X0_27_X5_X0_X31_M3_d N_29_X5_X0_X31_M3_g
+ N_X5_X0_13_X5_X0_X31_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_X31_M4 N_X5_X0_13_X5_X0_X31_M4_d N_X5_X0_X31_7_X5_X0_X31_M4_g
+ N_X5_X0_27_X5_X0_X31_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_X31_M5 N_X5_X0_X31_7_X5_X0_X31_M5_d N_29_X5_X0_X31_M5_g
+ N_VDD_X5_X0_X31_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_X32_M0 N_RESULT0_X5_X0_X32_M0_d N_X5_X0_X32_7_X5_X0_X32_M0_g
+ N_X5_X0_27_X5_X0_X32_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_X32_M1 N_X5_X0_28_X5_X0_X32_M1_d N_30_X5_X0_X32_M1_g
+ N_RESULT0_X5_X0_X32_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_X32_M2 N_X5_X0_X32_7_X5_X0_X32_M2_d N_30_X5_X0_X32_M2_g
+ N_GROUND_X5_X0_X32_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_X32_M3 N_RESULT0_X5_X0_X32_M3_d N_30_X5_X0_X32_M3_g
+ N_X5_X0_27_X5_X0_X32_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_X32_M4 N_X5_X0_28_X5_X0_X32_M4_d N_X5_X0_X32_7_X5_X0_X32_M4_g
+ N_RESULT0_X5_X0_X32_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_X32_M5 N_X5_X0_X32_7_X5_X0_X32_M5_d N_30_X5_X0_X32_M5_g
+ N_VDD_X5_X0_X32_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_X33_M0 N_X5_X0_28_X5_X0_X33_M0_d N_X5_X0_X33_7_X5_X0_X33_M0_g
+ N_X5_X0_26_X5_X0_X33_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_X33_M1 N_X5_X0_24_X5_X0_X33_M1_d N_29_X5_X0_X33_M1_g
+ N_X5_X0_28_X5_X0_X33_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_X33_M2 N_X5_X0_X33_7_X5_X0_X33_M2_d N_29_X5_X0_X33_M2_g
+ N_GROUND_X5_X0_X33_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_X33_M3 N_X5_X0_28_X5_X0_X33_M3_d N_29_X5_X0_X33_M3_g
+ N_X5_X0_26_X5_X0_X33_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_X33_M4 N_X5_X0_24_X5_X0_X33_M4_d N_X5_X0_X33_7_X5_X0_X33_M4_g
+ N_X5_X0_28_X5_X0_X33_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_X33_M5 N_X5_X0_X33_7_X5_X0_X33_M5_d N_29_X5_X0_X33_M5_g
+ N_VDD_X5_X0_X33_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_X34_M0 X5_X0_X34_7 N_X5_47_X5_X0_X34_M0_g N_X5_X0_X34_6_X5_X0_X34_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX5_X0_X34_M1 N_GROUND_X5_X0_X34_M1_d N_X5_48_X5_X0_X34_M1_g X5_X0_X34_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX5_X0_X34_M2 N_X5_X0_26_X5_X0_X34_M2_d N_X5_X0_X34_6_X5_X0_X34_M2_g
+ N_GROUND_X5_X0_X34_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X0_X34_M3 N_X5_X0_X34_6_X5_X0_X34_M3_d N_X5_47_X5_X0_X34_M3_g
+ N_VDD_X5_X0_X34_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_X34_M4 N_VDD_X5_X0_X34_M4_d N_X5_48_X5_X0_X34_M4_g
+ N_X5_X0_X34_6_X5_X0_X34_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X0_X34_M5 N_X5_X0_26_X5_X0_X34_M5_d N_X5_X0_X34_6_X5_X0_X34_M5_g
+ N_VDD_X5_X0_X34_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X0_X0_M0 N_GROUND_X5_X1_X0_X0_M0_d N_X5_X1_X0_X0_11_X5_X1_X0_X0_M0_g
+ N_X5_X1_30_X5_X1_X0_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M1 N_X5_X1_X0_X0_7_X5_X1_X0_X0_M1_d
+ N_X5_X1_X0_X0_10_X5_X1_X0_X0_M1_g N_GROUND_X5_X1_X0_X0_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M2 X5_X1_X0_X0_8 N_X5_X1_X0_X0_15_X5_X1_X0_X0_M2_g
+ N_X5_X1_X0_X0_7_X5_X1_X0_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M3 N_GROUND_X5_X1_X0_X0_M3_d N_X5_X1_X0_X0_16_X5_X1_X0_X0_M3_g
+ X5_X1_X0_X0_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M4 X5_X1_X0_X0_9 N_X5_X1_X0_X0_14_X5_X1_X0_X0_M4_g
+ N_GROUND_X5_X1_X0_X0_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M5 N_X5_X1_X0_X0_10_X5_X1_X0_X0_M5_d
+ N_X5_X1_X0_X0_15_X5_X1_X0_X0_M5_g X5_X1_X0_X0_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M6 N_GROUND_X5_X1_X0_X0_M6_d N_X5_X1_X0_X0_7_X5_X1_X0_X0_M6_g
+ N_X5_X1_X0_X0_10_X5_X1_X0_X0_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M7 N_X5_X1_X0_X0_11_X5_X1_X0_X0_M7_d N_X5_X1_30_X5_X1_X0_X0_M7_g
+ N_GROUND_X5_X1_X0_X0_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M8 X5_X1_X0_X0_12 N_CLK_X5_X1_X0_X0_M8_g
+ N_X5_X1_X0_X0_11_X5_X1_X0_X0_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M9 N_GROUND_X5_X1_X0_X0_M9_d N_X5_X1_X0_X0_10_X5_X1_X0_X0_M9_g
+ X5_X1_X0_X0_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M10 X5_X1_X0_X0_13 N_X5_X1_X0_X0_7_X5_X1_X0_X0_M10_g
+ N_GROUND_X5_X1_X0_X0_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M11 N_X5_X1_30_X5_X1_X0_X0_M11_d N_CLK_X5_X1_X0_X0_M11_g
+ X5_X1_X0_X0_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M12 N_GROUND_X5_X1_X0_X0_M12_d N_X5_X1_X0_X0_16_X5_X1_X0_X0_M12_g
+ N_X5_X1_X0_X0_14_X5_X1_X0_X0_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M13 N_X5_X1_X0_X0_15_X5_X1_X0_X0_M13_d N_CLK_X5_X1_X0_X0_M13_g
+ N_GROUND_X5_X1_X0_X0_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M14 N_VDD_X5_X1_X0_X0_M14_d N_X5_X1_X0_X0_16_X5_X1_X0_X0_M14_g
+ N_X5_X1_X0_X0_14_X5_X1_X0_X0_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M15 N_X5_X1_X0_X0_15_X5_X1_X0_X0_M15_d N_CLK_X5_X1_X0_X0_M15_g
+ N_VDD_X5_X1_X0_X0_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M16 N_VDD_X5_X1_X0_X0_M16_d N_X5_X1_X0_X0_7_X5_X1_X0_X0_M16_g
+ N_X5_X1_X0_X0_10_X5_X1_X0_X0_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M17 N_X5_X1_X0_X0_7_X5_X1_X0_X0_M17_d
+ N_X5_X1_X0_X0_10_X5_X1_X0_X0_M17_g N_VDD_X5_X1_X0_X0_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M18 N_VDD_X5_X1_X0_X0_M18_d N_X5_X1_X0_X0_11_X5_X1_X0_X0_M18_g
+ N_X5_X1_30_X5_X1_X0_X0_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_M19 N_X5_X1_X0_X0_11_X5_X1_X0_X0_M19_d N_X5_X1_30_X5_X1_X0_X0_M19_g
+ N_VDD_X5_X1_X0_X0_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_X20_M0 N_X5_X1_X0_X0_16_X5_X1_X0_X0_X20_M0_d
+ N_X5_X1_X0_X0_X20_7_X5_X1_X0_X0_X20_M0_g N_X5_X1_30_X5_X1_X0_X0_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_X20_M1 N_11_X5_X1_X0_X0_X20_M1_d N_X5_X1_22_X5_X1_X0_X0_X20_M1_g
+ N_X5_X1_X0_X0_16_X5_X1_X0_X0_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_X20_M2 N_X5_X1_X0_X0_X20_7_X5_X1_X0_X0_X20_M2_d
+ N_X5_X1_22_X5_X1_X0_X0_X20_M2_g N_GROUND_X5_X1_X0_X0_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X0_X20_M3 N_X5_X1_X0_X0_16_X5_X1_X0_X0_X20_M3_d
+ N_X5_X1_22_X5_X1_X0_X0_X20_M3_g N_X5_X1_30_X5_X1_X0_X0_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X0_X0_X20_M4 N_11_X5_X1_X0_X0_X20_M4_d
+ N_X5_X1_X0_X0_X20_7_X5_X1_X0_X0_X20_M4_g N_X5_X1_X0_X0_16_X5_X1_X0_X0_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X0_X0_X20_M5 N_X5_X1_X0_X0_X20_7_X5_X1_X0_X0_X20_M5_d
+ N_X5_X1_22_X5_X1_X0_X0_X20_M5_g N_VDD_X5_X1_X0_X0_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX5_X1_X0_X1_M0 N_GROUND_X5_X1_X0_X1_M0_d N_X5_X1_X0_X1_11_X5_X1_X0_X1_M0_g
+ N_X5_X1_31_X5_X1_X0_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M1 N_X5_X1_X0_X1_7_X5_X1_X0_X1_M1_d
+ N_X5_X1_X0_X1_10_X5_X1_X0_X1_M1_g N_GROUND_X5_X1_X0_X1_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M2 X5_X1_X0_X1_8 N_X5_X1_X0_X1_15_X5_X1_X0_X1_M2_g
+ N_X5_X1_X0_X1_7_X5_X1_X0_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M3 N_GROUND_X5_X1_X0_X1_M3_d N_X5_X1_X0_X1_16_X5_X1_X0_X1_M3_g
+ X5_X1_X0_X1_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M4 X5_X1_X0_X1_9 N_X5_X1_X0_X1_14_X5_X1_X0_X1_M4_g
+ N_GROUND_X5_X1_X0_X1_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M5 N_X5_X1_X0_X1_10_X5_X1_X0_X1_M5_d
+ N_X5_X1_X0_X1_15_X5_X1_X0_X1_M5_g X5_X1_X0_X1_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M6 N_GROUND_X5_X1_X0_X1_M6_d N_X5_X1_X0_X1_7_X5_X1_X0_X1_M6_g
+ N_X5_X1_X0_X1_10_X5_X1_X0_X1_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M7 N_X5_X1_X0_X1_11_X5_X1_X0_X1_M7_d N_X5_X1_31_X5_X1_X0_X1_M7_g
+ N_GROUND_X5_X1_X0_X1_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M8 X5_X1_X0_X1_12 N_CLK_X5_X1_X0_X1_M8_g
+ N_X5_X1_X0_X1_11_X5_X1_X0_X1_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M9 N_GROUND_X5_X1_X0_X1_M9_d N_X5_X1_X0_X1_10_X5_X1_X0_X1_M9_g
+ X5_X1_X0_X1_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M10 X5_X1_X0_X1_13 N_X5_X1_X0_X1_7_X5_X1_X0_X1_M10_g
+ N_GROUND_X5_X1_X0_X1_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M11 N_X5_X1_31_X5_X1_X0_X1_M11_d N_CLK_X5_X1_X0_X1_M11_g
+ X5_X1_X0_X1_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M12 N_GROUND_X5_X1_X0_X1_M12_d N_X5_X1_X0_X1_16_X5_X1_X0_X1_M12_g
+ N_X5_X1_X0_X1_14_X5_X1_X0_X1_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M13 N_X5_X1_X0_X1_15_X5_X1_X0_X1_M13_d N_CLK_X5_X1_X0_X1_M13_g
+ N_GROUND_X5_X1_X0_X1_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M14 N_VDD_X5_X1_X0_X1_M14_d N_X5_X1_X0_X1_16_X5_X1_X0_X1_M14_g
+ N_X5_X1_X0_X1_14_X5_X1_X0_X1_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M15 N_X5_X1_X0_X1_15_X5_X1_X0_X1_M15_d N_CLK_X5_X1_X0_X1_M15_g
+ N_VDD_X5_X1_X0_X1_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M16 N_VDD_X5_X1_X0_X1_M16_d N_X5_X1_X0_X1_7_X5_X1_X0_X1_M16_g
+ N_X5_X1_X0_X1_10_X5_X1_X0_X1_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M17 N_X5_X1_X0_X1_7_X5_X1_X0_X1_M17_d
+ N_X5_X1_X0_X1_10_X5_X1_X0_X1_M17_g N_VDD_X5_X1_X0_X1_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M18 N_VDD_X5_X1_X0_X1_M18_d N_X5_X1_X0_X1_11_X5_X1_X0_X1_M18_g
+ N_X5_X1_31_X5_X1_X0_X1_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_M19 N_X5_X1_X0_X1_11_X5_X1_X0_X1_M19_d N_X5_X1_31_X5_X1_X0_X1_M19_g
+ N_VDD_X5_X1_X0_X1_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_X20_M0 N_X5_X1_X0_X1_16_X5_X1_X0_X1_X20_M0_d
+ N_X5_X1_X0_X1_X20_7_X5_X1_X0_X1_X20_M0_g N_X5_X1_31_X5_X1_X0_X1_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_X20_M1 N_11_X5_X1_X0_X1_X20_M1_d N_X5_X1_23_X5_X1_X0_X1_X20_M1_g
+ N_X5_X1_X0_X1_16_X5_X1_X0_X1_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_X20_M2 N_X5_X1_X0_X1_X20_7_X5_X1_X0_X1_X20_M2_d
+ N_X5_X1_23_X5_X1_X0_X1_X20_M2_g N_GROUND_X5_X1_X0_X1_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX5_X1_X0_X1_X20_M3 N_X5_X1_X0_X1_16_X5_X1_X0_X1_X20_M3_d
+ N_X5_X1_23_X5_X1_X0_X1_X20_M3_g N_X5_X1_31_X5_X1_X0_X1_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X0_X1_X20_M4 N_11_X5_X1_X0_X1_X20_M4_d
+ N_X5_X1_X0_X1_X20_7_X5_X1_X0_X1_X20_M4_g N_X5_X1_X0_X1_16_X5_X1_X0_X1_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X0_X1_X20_M5 N_X5_X1_X0_X1_X20_7_X5_X1_X0_X1_X20_M5_d
+ N_X5_X1_23_X5_X1_X0_X1_X20_M5_g N_VDD_X5_X1_X0_X1_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX5_X1_X1_X0_M0 N_GROUND_X5_X1_X1_X0_M0_d N_X5_X1_X1_X0_11_X5_X1_X1_X0_M0_g
+ N_X5_X1_32_X5_X1_X1_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M1 N_X5_X1_X1_X0_7_X5_X1_X1_X0_M1_d
+ N_X5_X1_X1_X0_10_X5_X1_X1_X0_M1_g N_GROUND_X5_X1_X1_X0_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M2 X5_X1_X1_X0_8 N_X5_X1_X1_X0_15_X5_X1_X1_X0_M2_g
+ N_X5_X1_X1_X0_7_X5_X1_X1_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M3 N_GROUND_X5_X1_X1_X0_M3_d N_X5_X1_X1_X0_16_X5_X1_X1_X0_M3_g
+ X5_X1_X1_X0_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M4 X5_X1_X1_X0_9 N_X5_X1_X1_X0_14_X5_X1_X1_X0_M4_g
+ N_GROUND_X5_X1_X1_X0_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M5 N_X5_X1_X1_X0_10_X5_X1_X1_X0_M5_d
+ N_X5_X1_X1_X0_15_X5_X1_X1_X0_M5_g X5_X1_X1_X0_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M6 N_GROUND_X5_X1_X1_X0_M6_d N_X5_X1_X1_X0_7_X5_X1_X1_X0_M6_g
+ N_X5_X1_X1_X0_10_X5_X1_X1_X0_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M7 N_X5_X1_X1_X0_11_X5_X1_X1_X0_M7_d N_X5_X1_32_X5_X1_X1_X0_M7_g
+ N_GROUND_X5_X1_X1_X0_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M8 X5_X1_X1_X0_12 N_CLK_X5_X1_X1_X0_M8_g
+ N_X5_X1_X1_X0_11_X5_X1_X1_X0_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M9 N_GROUND_X5_X1_X1_X0_M9_d N_X5_X1_X1_X0_10_X5_X1_X1_X0_M9_g
+ X5_X1_X1_X0_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M10 X5_X1_X1_X0_13 N_X5_X1_X1_X0_7_X5_X1_X1_X0_M10_g
+ N_GROUND_X5_X1_X1_X0_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M11 N_X5_X1_32_X5_X1_X1_X0_M11_d N_CLK_X5_X1_X1_X0_M11_g
+ X5_X1_X1_X0_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M12 N_GROUND_X5_X1_X1_X0_M12_d N_X5_X1_X1_X0_16_X5_X1_X1_X0_M12_g
+ N_X5_X1_X1_X0_14_X5_X1_X1_X0_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M13 N_X5_X1_X1_X0_15_X5_X1_X1_X0_M13_d N_CLK_X5_X1_X1_X0_M13_g
+ N_GROUND_X5_X1_X1_X0_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M14 N_VDD_X5_X1_X1_X0_M14_d N_X5_X1_X1_X0_16_X5_X1_X1_X0_M14_g
+ N_X5_X1_X1_X0_14_X5_X1_X1_X0_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M15 N_X5_X1_X1_X0_15_X5_X1_X1_X0_M15_d N_CLK_X5_X1_X1_X0_M15_g
+ N_VDD_X5_X1_X1_X0_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M16 N_VDD_X5_X1_X1_X0_M16_d N_X5_X1_X1_X0_7_X5_X1_X1_X0_M16_g
+ N_X5_X1_X1_X0_10_X5_X1_X1_X0_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M17 N_X5_X1_X1_X0_7_X5_X1_X1_X0_M17_d
+ N_X5_X1_X1_X0_10_X5_X1_X1_X0_M17_g N_VDD_X5_X1_X1_X0_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M18 N_VDD_X5_X1_X1_X0_M18_d N_X5_X1_X1_X0_11_X5_X1_X1_X0_M18_g
+ N_X5_X1_32_X5_X1_X1_X0_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_M19 N_X5_X1_X1_X0_11_X5_X1_X1_X0_M19_d N_X5_X1_32_X5_X1_X1_X0_M19_g
+ N_VDD_X5_X1_X1_X0_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_X20_M0 N_X5_X1_X1_X0_16_X5_X1_X1_X0_X20_M0_d
+ N_X5_X1_X1_X0_X20_7_X5_X1_X1_X0_X20_M0_g N_X5_X1_32_X5_X1_X1_X0_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_X20_M1 N_11_X5_X1_X1_X0_X20_M1_d N_X5_X1_24_X5_X1_X1_X0_X20_M1_g
+ N_X5_X1_X1_X0_16_X5_X1_X1_X0_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_X20_M2 N_X5_X1_X1_X0_X20_7_X5_X1_X1_X0_X20_M2_d
+ N_X5_X1_24_X5_X1_X1_X0_X20_M2_g N_GROUND_X5_X1_X1_X0_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X0_X20_M3 N_X5_X1_X1_X0_16_X5_X1_X1_X0_X20_M3_d
+ N_X5_X1_24_X5_X1_X1_X0_X20_M3_g N_X5_X1_32_X5_X1_X1_X0_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X1_X0_X20_M4 N_11_X5_X1_X1_X0_X20_M4_d
+ N_X5_X1_X1_X0_X20_7_X5_X1_X1_X0_X20_M4_g N_X5_X1_X1_X0_16_X5_X1_X1_X0_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X1_X0_X20_M5 N_X5_X1_X1_X0_X20_7_X5_X1_X1_X0_X20_M5_d
+ N_X5_X1_24_X5_X1_X1_X0_X20_M5_g N_VDD_X5_X1_X1_X0_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX5_X1_X1_X1_M0 N_GROUND_X5_X1_X1_X1_M0_d N_X5_X1_X1_X1_11_X5_X1_X1_X1_M0_g
+ N_X5_X1_33_X5_X1_X1_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M1 N_X5_X1_X1_X1_7_X5_X1_X1_X1_M1_d
+ N_X5_X1_X1_X1_10_X5_X1_X1_X1_M1_g N_GROUND_X5_X1_X1_X1_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M2 X5_X1_X1_X1_8 N_X5_X1_X1_X1_15_X5_X1_X1_X1_M2_g
+ N_X5_X1_X1_X1_7_X5_X1_X1_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M3 N_GROUND_X5_X1_X1_X1_M3_d N_X5_X1_X1_X1_16_X5_X1_X1_X1_M3_g
+ X5_X1_X1_X1_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M4 X5_X1_X1_X1_9 N_X5_X1_X1_X1_14_X5_X1_X1_X1_M4_g
+ N_GROUND_X5_X1_X1_X1_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M5 N_X5_X1_X1_X1_10_X5_X1_X1_X1_M5_d
+ N_X5_X1_X1_X1_15_X5_X1_X1_X1_M5_g X5_X1_X1_X1_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M6 N_GROUND_X5_X1_X1_X1_M6_d N_X5_X1_X1_X1_7_X5_X1_X1_X1_M6_g
+ N_X5_X1_X1_X1_10_X5_X1_X1_X1_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M7 N_X5_X1_X1_X1_11_X5_X1_X1_X1_M7_d N_X5_X1_33_X5_X1_X1_X1_M7_g
+ N_GROUND_X5_X1_X1_X1_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M8 X5_X1_X1_X1_12 N_CLK_X5_X1_X1_X1_M8_g
+ N_X5_X1_X1_X1_11_X5_X1_X1_X1_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M9 N_GROUND_X5_X1_X1_X1_M9_d N_X5_X1_X1_X1_10_X5_X1_X1_X1_M9_g
+ X5_X1_X1_X1_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M10 X5_X1_X1_X1_13 N_X5_X1_X1_X1_7_X5_X1_X1_X1_M10_g
+ N_GROUND_X5_X1_X1_X1_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M11 N_X5_X1_33_X5_X1_X1_X1_M11_d N_CLK_X5_X1_X1_X1_M11_g
+ X5_X1_X1_X1_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M12 N_GROUND_X5_X1_X1_X1_M12_d N_X5_X1_X1_X1_16_X5_X1_X1_X1_M12_g
+ N_X5_X1_X1_X1_14_X5_X1_X1_X1_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M13 N_X5_X1_X1_X1_15_X5_X1_X1_X1_M13_d N_CLK_X5_X1_X1_X1_M13_g
+ N_GROUND_X5_X1_X1_X1_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M14 N_VDD_X5_X1_X1_X1_M14_d N_X5_X1_X1_X1_16_X5_X1_X1_X1_M14_g
+ N_X5_X1_X1_X1_14_X5_X1_X1_X1_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M15 N_X5_X1_X1_X1_15_X5_X1_X1_X1_M15_d N_CLK_X5_X1_X1_X1_M15_g
+ N_VDD_X5_X1_X1_X1_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M16 N_VDD_X5_X1_X1_X1_M16_d N_X5_X1_X1_X1_7_X5_X1_X1_X1_M16_g
+ N_X5_X1_X1_X1_10_X5_X1_X1_X1_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M17 N_X5_X1_X1_X1_7_X5_X1_X1_X1_M17_d
+ N_X5_X1_X1_X1_10_X5_X1_X1_X1_M17_g N_VDD_X5_X1_X1_X1_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M18 N_VDD_X5_X1_X1_X1_M18_d N_X5_X1_X1_X1_11_X5_X1_X1_X1_M18_g
+ N_X5_X1_33_X5_X1_X1_X1_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_M19 N_X5_X1_X1_X1_11_X5_X1_X1_X1_M19_d N_X5_X1_33_X5_X1_X1_X1_M19_g
+ N_VDD_X5_X1_X1_X1_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_X20_M0 N_X5_X1_X1_X1_16_X5_X1_X1_X1_X20_M0_d
+ N_X5_X1_X1_X1_X20_7_X5_X1_X1_X1_X20_M0_g N_X5_X1_33_X5_X1_X1_X1_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_X20_M1 N_11_X5_X1_X1_X1_X20_M1_d N_X5_X1_25_X5_X1_X1_X1_X20_M1_g
+ N_X5_X1_X1_X1_16_X5_X1_X1_X1_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_X20_M2 N_X5_X1_X1_X1_X20_7_X5_X1_X1_X1_X20_M2_d
+ N_X5_X1_25_X5_X1_X1_X1_X20_M2_g N_GROUND_X5_X1_X1_X1_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX5_X1_X1_X1_X20_M3 N_X5_X1_X1_X1_16_X5_X1_X1_X1_X20_M3_d
+ N_X5_X1_25_X5_X1_X1_X1_X20_M3_g N_X5_X1_33_X5_X1_X1_X1_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X1_X1_X20_M4 N_11_X5_X1_X1_X1_X20_M4_d
+ N_X5_X1_X1_X1_X20_7_X5_X1_X1_X1_X20_M4_g N_X5_X1_X1_X1_16_X5_X1_X1_X1_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X1_X1_X20_M5 N_X5_X1_X1_X1_X20_7_X5_X1_X1_X1_X20_M5_d
+ N_X5_X1_25_X5_X1_X1_X1_X20_M5_g N_VDD_X5_X1_X1_X1_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX5_X1_X2_X0_M0 N_GROUND_X5_X1_X2_X0_M0_d N_X5_X1_X2_X0_11_X5_X1_X2_X0_M0_g
+ N_X5_X1_34_X5_X1_X2_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M1 N_X5_X1_X2_X0_7_X5_X1_X2_X0_M1_d
+ N_X5_X1_X2_X0_10_X5_X1_X2_X0_M1_g N_GROUND_X5_X1_X2_X0_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M2 X5_X1_X2_X0_8 N_X5_X1_X2_X0_15_X5_X1_X2_X0_M2_g
+ N_X5_X1_X2_X0_7_X5_X1_X2_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M3 N_GROUND_X5_X1_X2_X0_M3_d N_X5_X1_X2_X0_16_X5_X1_X2_X0_M3_g
+ X5_X1_X2_X0_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M4 X5_X1_X2_X0_9 N_X5_X1_X2_X0_14_X5_X1_X2_X0_M4_g
+ N_GROUND_X5_X1_X2_X0_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M5 N_X5_X1_X2_X0_10_X5_X1_X2_X0_M5_d
+ N_X5_X1_X2_X0_15_X5_X1_X2_X0_M5_g X5_X1_X2_X0_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M6 N_GROUND_X5_X1_X2_X0_M6_d N_X5_X1_X2_X0_7_X5_X1_X2_X0_M6_g
+ N_X5_X1_X2_X0_10_X5_X1_X2_X0_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M7 N_X5_X1_X2_X0_11_X5_X1_X2_X0_M7_d N_X5_X1_34_X5_X1_X2_X0_M7_g
+ N_GROUND_X5_X1_X2_X0_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M8 X5_X1_X2_X0_12 N_CLK_X5_X1_X2_X0_M8_g
+ N_X5_X1_X2_X0_11_X5_X1_X2_X0_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M9 N_GROUND_X5_X1_X2_X0_M9_d N_X5_X1_X2_X0_10_X5_X1_X2_X0_M9_g
+ X5_X1_X2_X0_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M10 X5_X1_X2_X0_13 N_X5_X1_X2_X0_7_X5_X1_X2_X0_M10_g
+ N_GROUND_X5_X1_X2_X0_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M11 N_X5_X1_34_X5_X1_X2_X0_M11_d N_CLK_X5_X1_X2_X0_M11_g
+ X5_X1_X2_X0_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M12 N_GROUND_X5_X1_X2_X0_M12_d N_X5_X1_X2_X0_16_X5_X1_X2_X0_M12_g
+ N_X5_X1_X2_X0_14_X5_X1_X2_X0_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M13 N_X5_X1_X2_X0_15_X5_X1_X2_X0_M13_d N_CLK_X5_X1_X2_X0_M13_g
+ N_GROUND_X5_X1_X2_X0_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M14 N_VDD_X5_X1_X2_X0_M14_d N_X5_X1_X2_X0_16_X5_X1_X2_X0_M14_g
+ N_X5_X1_X2_X0_14_X5_X1_X2_X0_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M15 N_X5_X1_X2_X0_15_X5_X1_X2_X0_M15_d N_CLK_X5_X1_X2_X0_M15_g
+ N_VDD_X5_X1_X2_X0_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M16 N_VDD_X5_X1_X2_X0_M16_d N_X5_X1_X2_X0_7_X5_X1_X2_X0_M16_g
+ N_X5_X1_X2_X0_10_X5_X1_X2_X0_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M17 N_X5_X1_X2_X0_7_X5_X1_X2_X0_M17_d
+ N_X5_X1_X2_X0_10_X5_X1_X2_X0_M17_g N_VDD_X5_X1_X2_X0_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M18 N_VDD_X5_X1_X2_X0_M18_d N_X5_X1_X2_X0_11_X5_X1_X2_X0_M18_g
+ N_X5_X1_34_X5_X1_X2_X0_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_M19 N_X5_X1_X2_X0_11_X5_X1_X2_X0_M19_d N_X5_X1_34_X5_X1_X2_X0_M19_g
+ N_VDD_X5_X1_X2_X0_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_X20_M0 N_X5_X1_X2_X0_16_X5_X1_X2_X0_X20_M0_d
+ N_X5_X1_X2_X0_X20_7_X5_X1_X2_X0_X20_M0_g N_X5_X1_34_X5_X1_X2_X0_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_X20_M1 N_11_X5_X1_X2_X0_X20_M1_d N_X5_X1_26_X5_X1_X2_X0_X20_M1_g
+ N_X5_X1_X2_X0_16_X5_X1_X2_X0_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_X20_M2 N_X5_X1_X2_X0_X20_7_X5_X1_X2_X0_X20_M2_d
+ N_X5_X1_26_X5_X1_X2_X0_X20_M2_g N_GROUND_X5_X1_X2_X0_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X0_X20_M3 N_X5_X1_X2_X0_16_X5_X1_X2_X0_X20_M3_d
+ N_X5_X1_26_X5_X1_X2_X0_X20_M3_g N_X5_X1_34_X5_X1_X2_X0_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X2_X0_X20_M4 N_11_X5_X1_X2_X0_X20_M4_d
+ N_X5_X1_X2_X0_X20_7_X5_X1_X2_X0_X20_M4_g N_X5_X1_X2_X0_16_X5_X1_X2_X0_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X2_X0_X20_M5 N_X5_X1_X2_X0_X20_7_X5_X1_X2_X0_X20_M5_d
+ N_X5_X1_26_X5_X1_X2_X0_X20_M5_g N_VDD_X5_X1_X2_X0_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX5_X1_X2_X1_M0 N_GROUND_X5_X1_X2_X1_M0_d N_X5_X1_X2_X1_11_X5_X1_X2_X1_M0_g
+ N_X5_X1_35_X5_X1_X2_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M1 N_X5_X1_X2_X1_7_X5_X1_X2_X1_M1_d
+ N_X5_X1_X2_X1_10_X5_X1_X2_X1_M1_g N_GROUND_X5_X1_X2_X1_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M2 X5_X1_X2_X1_8 N_X5_X1_X2_X1_15_X5_X1_X2_X1_M2_g
+ N_X5_X1_X2_X1_7_X5_X1_X2_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M3 N_GROUND_X5_X1_X2_X1_M3_d N_X5_X1_X2_X1_16_X5_X1_X2_X1_M3_g
+ X5_X1_X2_X1_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M4 X5_X1_X2_X1_9 N_X5_X1_X2_X1_14_X5_X1_X2_X1_M4_g
+ N_GROUND_X5_X1_X2_X1_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M5 N_X5_X1_X2_X1_10_X5_X1_X2_X1_M5_d
+ N_X5_X1_X2_X1_15_X5_X1_X2_X1_M5_g X5_X1_X2_X1_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M6 N_GROUND_X5_X1_X2_X1_M6_d N_X5_X1_X2_X1_7_X5_X1_X2_X1_M6_g
+ N_X5_X1_X2_X1_10_X5_X1_X2_X1_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M7 N_X5_X1_X2_X1_11_X5_X1_X2_X1_M7_d N_X5_X1_35_X5_X1_X2_X1_M7_g
+ N_GROUND_X5_X1_X2_X1_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M8 X5_X1_X2_X1_12 N_CLK_X5_X1_X2_X1_M8_g
+ N_X5_X1_X2_X1_11_X5_X1_X2_X1_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M9 N_GROUND_X5_X1_X2_X1_M9_d N_X5_X1_X2_X1_10_X5_X1_X2_X1_M9_g
+ X5_X1_X2_X1_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M10 X5_X1_X2_X1_13 N_X5_X1_X2_X1_7_X5_X1_X2_X1_M10_g
+ N_GROUND_X5_X1_X2_X1_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M11 N_X5_X1_35_X5_X1_X2_X1_M11_d N_CLK_X5_X1_X2_X1_M11_g
+ X5_X1_X2_X1_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M12 N_GROUND_X5_X1_X2_X1_M12_d N_X5_X1_X2_X1_16_X5_X1_X2_X1_M12_g
+ N_X5_X1_X2_X1_14_X5_X1_X2_X1_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M13 N_X5_X1_X2_X1_15_X5_X1_X2_X1_M13_d N_CLK_X5_X1_X2_X1_M13_g
+ N_GROUND_X5_X1_X2_X1_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M14 N_VDD_X5_X1_X2_X1_M14_d N_X5_X1_X2_X1_16_X5_X1_X2_X1_M14_g
+ N_X5_X1_X2_X1_14_X5_X1_X2_X1_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M15 N_X5_X1_X2_X1_15_X5_X1_X2_X1_M15_d N_CLK_X5_X1_X2_X1_M15_g
+ N_VDD_X5_X1_X2_X1_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M16 N_VDD_X5_X1_X2_X1_M16_d N_X5_X1_X2_X1_7_X5_X1_X2_X1_M16_g
+ N_X5_X1_X2_X1_10_X5_X1_X2_X1_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M17 N_X5_X1_X2_X1_7_X5_X1_X2_X1_M17_d
+ N_X5_X1_X2_X1_10_X5_X1_X2_X1_M17_g N_VDD_X5_X1_X2_X1_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M18 N_VDD_X5_X1_X2_X1_M18_d N_X5_X1_X2_X1_11_X5_X1_X2_X1_M18_g
+ N_X5_X1_35_X5_X1_X2_X1_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_M19 N_X5_X1_X2_X1_11_X5_X1_X2_X1_M19_d N_X5_X1_35_X5_X1_X2_X1_M19_g
+ N_VDD_X5_X1_X2_X1_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_X20_M0 N_X5_X1_X2_X1_16_X5_X1_X2_X1_X20_M0_d
+ N_X5_X1_X2_X1_X20_7_X5_X1_X2_X1_X20_M0_g N_X5_X1_35_X5_X1_X2_X1_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_X20_M1 N_11_X5_X1_X2_X1_X20_M1_d N_X5_X1_27_X5_X1_X2_X1_X20_M1_g
+ N_X5_X1_X2_X1_16_X5_X1_X2_X1_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_X20_M2 N_X5_X1_X2_X1_X20_7_X5_X1_X2_X1_X20_M2_d
+ N_X5_X1_27_X5_X1_X2_X1_X20_M2_g N_GROUND_X5_X1_X2_X1_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX5_X1_X2_X1_X20_M3 N_X5_X1_X2_X1_16_X5_X1_X2_X1_X20_M3_d
+ N_X5_X1_27_X5_X1_X2_X1_X20_M3_g N_X5_X1_35_X5_X1_X2_X1_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X2_X1_X20_M4 N_11_X5_X1_X2_X1_X20_M4_d
+ N_X5_X1_X2_X1_X20_7_X5_X1_X2_X1_X20_M4_g N_X5_X1_X2_X1_16_X5_X1_X2_X1_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X2_X1_X20_M5 N_X5_X1_X2_X1_X20_7_X5_X1_X2_X1_X20_M5_d
+ N_X5_X1_27_X5_X1_X2_X1_X20_M5_g N_VDD_X5_X1_X2_X1_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX5_X1_X3_X0_M0 N_GROUND_X5_X1_X3_X0_M0_d N_X5_X1_X3_X0_11_X5_X1_X3_X0_M0_g
+ N_X5_X1_36_X5_X1_X3_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M1 N_X5_X1_X3_X0_7_X5_X1_X3_X0_M1_d
+ N_X5_X1_X3_X0_10_X5_X1_X3_X0_M1_g N_GROUND_X5_X1_X3_X0_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M2 X5_X1_X3_X0_8 N_X5_X1_X3_X0_15_X5_X1_X3_X0_M2_g
+ N_X5_X1_X3_X0_7_X5_X1_X3_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M3 N_GROUND_X5_X1_X3_X0_M3_d N_X5_X1_X3_X0_16_X5_X1_X3_X0_M3_g
+ X5_X1_X3_X0_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M4 X5_X1_X3_X0_9 N_X5_X1_X3_X0_14_X5_X1_X3_X0_M4_g
+ N_GROUND_X5_X1_X3_X0_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M5 N_X5_X1_X3_X0_10_X5_X1_X3_X0_M5_d
+ N_X5_X1_X3_X0_15_X5_X1_X3_X0_M5_g X5_X1_X3_X0_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M6 N_GROUND_X5_X1_X3_X0_M6_d N_X5_X1_X3_X0_7_X5_X1_X3_X0_M6_g
+ N_X5_X1_X3_X0_10_X5_X1_X3_X0_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M7 N_X5_X1_X3_X0_11_X5_X1_X3_X0_M7_d N_X5_X1_36_X5_X1_X3_X0_M7_g
+ N_GROUND_X5_X1_X3_X0_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M8 X5_X1_X3_X0_12 N_CLK_X5_X1_X3_X0_M8_g
+ N_X5_X1_X3_X0_11_X5_X1_X3_X0_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M9 N_GROUND_X5_X1_X3_X0_M9_d N_X5_X1_X3_X0_10_X5_X1_X3_X0_M9_g
+ X5_X1_X3_X0_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M10 X5_X1_X3_X0_13 N_X5_X1_X3_X0_7_X5_X1_X3_X0_M10_g
+ N_GROUND_X5_X1_X3_X0_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M11 N_X5_X1_36_X5_X1_X3_X0_M11_d N_CLK_X5_X1_X3_X0_M11_g
+ X5_X1_X3_X0_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M12 N_GROUND_X5_X1_X3_X0_M12_d N_X5_X1_X3_X0_16_X5_X1_X3_X0_M12_g
+ N_X5_X1_X3_X0_14_X5_X1_X3_X0_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M13 N_X5_X1_X3_X0_15_X5_X1_X3_X0_M13_d N_CLK_X5_X1_X3_X0_M13_g
+ N_GROUND_X5_X1_X3_X0_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M14 N_VDD_X5_X1_X3_X0_M14_d N_X5_X1_X3_X0_16_X5_X1_X3_X0_M14_g
+ N_X5_X1_X3_X0_14_X5_X1_X3_X0_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M15 N_X5_X1_X3_X0_15_X5_X1_X3_X0_M15_d N_CLK_X5_X1_X3_X0_M15_g
+ N_VDD_X5_X1_X3_X0_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M16 N_VDD_X5_X1_X3_X0_M16_d N_X5_X1_X3_X0_7_X5_X1_X3_X0_M16_g
+ N_X5_X1_X3_X0_10_X5_X1_X3_X0_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M17 N_X5_X1_X3_X0_7_X5_X1_X3_X0_M17_d
+ N_X5_X1_X3_X0_10_X5_X1_X3_X0_M17_g N_VDD_X5_X1_X3_X0_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M18 N_VDD_X5_X1_X3_X0_M18_d N_X5_X1_X3_X0_11_X5_X1_X3_X0_M18_g
+ N_X5_X1_36_X5_X1_X3_X0_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_M19 N_X5_X1_X3_X0_11_X5_X1_X3_X0_M19_d N_X5_X1_36_X5_X1_X3_X0_M19_g
+ N_VDD_X5_X1_X3_X0_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_X20_M0 N_X5_X1_X3_X0_16_X5_X1_X3_X0_X20_M0_d
+ N_X5_X1_X3_X0_X20_7_X5_X1_X3_X0_X20_M0_g N_X5_X1_36_X5_X1_X3_X0_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_X20_M1 N_11_X5_X1_X3_X0_X20_M1_d N_X5_X1_28_X5_X1_X3_X0_X20_M1_g
+ N_X5_X1_X3_X0_16_X5_X1_X3_X0_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_X20_M2 N_X5_X1_X3_X0_X20_7_X5_X1_X3_X0_X20_M2_d
+ N_X5_X1_28_X5_X1_X3_X0_X20_M2_g N_GROUND_X5_X1_X3_X0_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X0_X20_M3 N_X5_X1_X3_X0_16_X5_X1_X3_X0_X20_M3_d
+ N_X5_X1_28_X5_X1_X3_X0_X20_M3_g N_X5_X1_36_X5_X1_X3_X0_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X3_X0_X20_M4 N_11_X5_X1_X3_X0_X20_M4_d
+ N_X5_X1_X3_X0_X20_7_X5_X1_X3_X0_X20_M4_g N_X5_X1_X3_X0_16_X5_X1_X3_X0_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X3_X0_X20_M5 N_X5_X1_X3_X0_X20_7_X5_X1_X3_X0_X20_M5_d
+ N_X5_X1_28_X5_X1_X3_X0_X20_M5_g N_VDD_X5_X1_X3_X0_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX5_X1_X3_X1_M0 N_GROUND_X5_X1_X3_X1_M0_d N_X5_X1_X3_X1_11_X5_X1_X3_X1_M0_g
+ N_X5_X1_37_X5_X1_X3_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M1 N_X5_X1_X3_X1_7_X5_X1_X3_X1_M1_d
+ N_X5_X1_X3_X1_10_X5_X1_X3_X1_M1_g N_GROUND_X5_X1_X3_X1_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M2 X5_X1_X3_X1_8 N_X5_X1_X3_X1_15_X5_X1_X3_X1_M2_g
+ N_X5_X1_X3_X1_7_X5_X1_X3_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M3 N_GROUND_X5_X1_X3_X1_M3_d N_X5_X1_X3_X1_16_X5_X1_X3_X1_M3_g
+ X5_X1_X3_X1_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M4 X5_X1_X3_X1_9 N_X5_X1_X3_X1_14_X5_X1_X3_X1_M4_g
+ N_GROUND_X5_X1_X3_X1_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M5 N_X5_X1_X3_X1_10_X5_X1_X3_X1_M5_d
+ N_X5_X1_X3_X1_15_X5_X1_X3_X1_M5_g X5_X1_X3_X1_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M6 N_GROUND_X5_X1_X3_X1_M6_d N_X5_X1_X3_X1_7_X5_X1_X3_X1_M6_g
+ N_X5_X1_X3_X1_10_X5_X1_X3_X1_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M7 N_X5_X1_X3_X1_11_X5_X1_X3_X1_M7_d N_X5_X1_37_X5_X1_X3_X1_M7_g
+ N_GROUND_X5_X1_X3_X1_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M8 X5_X1_X3_X1_12 N_CLK_X5_X1_X3_X1_M8_g
+ N_X5_X1_X3_X1_11_X5_X1_X3_X1_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M9 N_GROUND_X5_X1_X3_X1_M9_d N_X5_X1_X3_X1_10_X5_X1_X3_X1_M9_g
+ X5_X1_X3_X1_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M10 X5_X1_X3_X1_13 N_X5_X1_X3_X1_7_X5_X1_X3_X1_M10_g
+ N_GROUND_X5_X1_X3_X1_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M11 N_X5_X1_37_X5_X1_X3_X1_M11_d N_CLK_X5_X1_X3_X1_M11_g
+ X5_X1_X3_X1_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M12 N_GROUND_X5_X1_X3_X1_M12_d N_X5_X1_X3_X1_16_X5_X1_X3_X1_M12_g
+ N_X5_X1_X3_X1_14_X5_X1_X3_X1_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M13 N_X5_X1_X3_X1_15_X5_X1_X3_X1_M13_d N_CLK_X5_X1_X3_X1_M13_g
+ N_GROUND_X5_X1_X3_X1_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M14 N_VDD_X5_X1_X3_X1_M14_d N_X5_X1_X3_X1_16_X5_X1_X3_X1_M14_g
+ N_X5_X1_X3_X1_14_X5_X1_X3_X1_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M15 N_X5_X1_X3_X1_15_X5_X1_X3_X1_M15_d N_CLK_X5_X1_X3_X1_M15_g
+ N_VDD_X5_X1_X3_X1_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M16 N_VDD_X5_X1_X3_X1_M16_d N_X5_X1_X3_X1_7_X5_X1_X3_X1_M16_g
+ N_X5_X1_X3_X1_10_X5_X1_X3_X1_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M17 N_X5_X1_X3_X1_7_X5_X1_X3_X1_M17_d
+ N_X5_X1_X3_X1_10_X5_X1_X3_X1_M17_g N_VDD_X5_X1_X3_X1_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M18 N_VDD_X5_X1_X3_X1_M18_d N_X5_X1_X3_X1_11_X5_X1_X3_X1_M18_g
+ N_X5_X1_37_X5_X1_X3_X1_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_M19 N_X5_X1_X3_X1_11_X5_X1_X3_X1_M19_d N_X5_X1_37_X5_X1_X3_X1_M19_g
+ N_VDD_X5_X1_X3_X1_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_X20_M0 N_X5_X1_X3_X1_16_X5_X1_X3_X1_X20_M0_d
+ N_X5_X1_X3_X1_X20_7_X5_X1_X3_X1_X20_M0_g N_X5_X1_37_X5_X1_X3_X1_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_X20_M1 N_11_X5_X1_X3_X1_X20_M1_d N_X5_X1_29_X5_X1_X3_X1_X20_M1_g
+ N_X5_X1_X3_X1_16_X5_X1_X3_X1_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_X20_M2 N_X5_X1_X3_X1_X20_7_X5_X1_X3_X1_X20_M2_d
+ N_X5_X1_29_X5_X1_X3_X1_X20_M2_g N_GROUND_X5_X1_X3_X1_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX5_X1_X3_X1_X20_M3 N_X5_X1_X3_X1_16_X5_X1_X3_X1_X20_M3_d
+ N_X5_X1_29_X5_X1_X3_X1_X20_M3_g N_X5_X1_37_X5_X1_X3_X1_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X3_X1_X20_M4 N_11_X5_X1_X3_X1_X20_M4_d
+ N_X5_X1_X3_X1_X20_7_X5_X1_X3_X1_X20_M4_g N_X5_X1_X3_X1_16_X5_X1_X3_X1_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X3_X1_X20_M5 N_X5_X1_X3_X1_X20_7_X5_X1_X3_X1_X20_M5_d
+ N_X5_X1_29_X5_X1_X3_X1_X20_M5_g N_VDD_X5_X1_X3_X1_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX5_X1_X4_X0_M0 X5_X1_X4_X0_7 N_19_X5_X1_X4_X0_M0_g
+ N_X5_X1_X4_X0_6_X5_X1_X4_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX5_X1_X4_X0_M1 N_GROUND_X5_X1_X4_X0_M1_d N_34_X5_X1_X4_X0_M1_g X5_X1_X4_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX5_X1_X4_X0_M2 N_X5_X1_22_X5_X1_X4_X0_M2_d N_X5_X1_X4_X0_6_X5_X1_X4_X0_M2_g
+ N_GROUND_X5_X1_X4_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X4_X0_M3 N_X5_X1_X4_X0_6_X5_X1_X4_X0_M3_d N_19_X5_X1_X4_X0_M3_g
+ N_VDD_X5_X1_X4_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X4_X0_M4 N_VDD_X5_X1_X4_X0_M4_d N_34_X5_X1_X4_X0_M4_g
+ N_X5_X1_X4_X0_6_X5_X1_X4_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X4_X0_M5 N_X5_X1_22_X5_X1_X4_X0_M5_d N_X5_X1_X4_X0_6_X5_X1_X4_X0_M5_g
+ N_VDD_X5_X1_X4_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X4_X1_M0 X5_X1_X4_X1_7 N_20_X5_X1_X4_X1_M0_g
+ N_X5_X1_X4_X1_6_X5_X1_X4_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX5_X1_X4_X1_M1 N_GROUND_X5_X1_X4_X1_M1_d N_34_X5_X1_X4_X1_M1_g X5_X1_X4_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX5_X1_X4_X1_M2 N_X5_X1_23_X5_X1_X4_X1_M2_d N_X5_X1_X4_X1_6_X5_X1_X4_X1_M2_g
+ N_GROUND_X5_X1_X4_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X4_X1_M3 N_X5_X1_X4_X1_6_X5_X1_X4_X1_M3_d N_20_X5_X1_X4_X1_M3_g
+ N_VDD_X5_X1_X4_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X4_X1_M4 N_VDD_X5_X1_X4_X1_M4_d N_34_X5_X1_X4_X1_M4_g
+ N_X5_X1_X4_X1_6_X5_X1_X4_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X4_X1_M5 N_X5_X1_23_X5_X1_X4_X1_M5_d N_X5_X1_X4_X1_6_X5_X1_X4_X1_M5_g
+ N_VDD_X5_X1_X4_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X5_X0_M0 X5_X1_X5_X0_7 N_21_X5_X1_X5_X0_M0_g
+ N_X5_X1_X5_X0_6_X5_X1_X5_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX5_X1_X5_X0_M1 N_GROUND_X5_X1_X5_X0_M1_d N_34_X5_X1_X5_X0_M1_g X5_X1_X5_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX5_X1_X5_X0_M2 N_X5_X1_24_X5_X1_X5_X0_M2_d N_X5_X1_X5_X0_6_X5_X1_X5_X0_M2_g
+ N_GROUND_X5_X1_X5_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X5_X0_M3 N_X5_X1_X5_X0_6_X5_X1_X5_X0_M3_d N_21_X5_X1_X5_X0_M3_g
+ N_VDD_X5_X1_X5_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X5_X0_M4 N_VDD_X5_X1_X5_X0_M4_d N_34_X5_X1_X5_X0_M4_g
+ N_X5_X1_X5_X0_6_X5_X1_X5_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X5_X0_M5 N_X5_X1_24_X5_X1_X5_X0_M5_d N_X5_X1_X5_X0_6_X5_X1_X5_X0_M5_g
+ N_VDD_X5_X1_X5_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X5_X1_M0 X5_X1_X5_X1_7 N_22_X5_X1_X5_X1_M0_g
+ N_X5_X1_X5_X1_6_X5_X1_X5_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX5_X1_X5_X1_M1 N_GROUND_X5_X1_X5_X1_M1_d N_34_X5_X1_X5_X1_M1_g X5_X1_X5_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX5_X1_X5_X1_M2 N_X5_X1_25_X5_X1_X5_X1_M2_d N_X5_X1_X5_X1_6_X5_X1_X5_X1_M2_g
+ N_GROUND_X5_X1_X5_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X5_X1_M3 N_X5_X1_X5_X1_6_X5_X1_X5_X1_M3_d N_22_X5_X1_X5_X1_M3_g
+ N_VDD_X5_X1_X5_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X5_X1_M4 N_VDD_X5_X1_X5_X1_M4_d N_34_X5_X1_X5_X1_M4_g
+ N_X5_X1_X5_X1_6_X5_X1_X5_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X5_X1_M5 N_X5_X1_25_X5_X1_X5_X1_M5_d N_X5_X1_X5_X1_6_X5_X1_X5_X1_M5_g
+ N_VDD_X5_X1_X5_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X6_X0_M0 X5_X1_X6_X0_7 N_23_X5_X1_X6_X0_M0_g
+ N_X5_X1_X6_X0_6_X5_X1_X6_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX5_X1_X6_X0_M1 N_GROUND_X5_X1_X6_X0_M1_d N_34_X5_X1_X6_X0_M1_g X5_X1_X6_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX5_X1_X6_X0_M2 N_X5_X1_26_X5_X1_X6_X0_M2_d N_X5_X1_X6_X0_6_X5_X1_X6_X0_M2_g
+ N_GROUND_X5_X1_X6_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X6_X0_M3 N_X5_X1_X6_X0_6_X5_X1_X6_X0_M3_d N_23_X5_X1_X6_X0_M3_g
+ N_VDD_X5_X1_X6_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X6_X0_M4 N_VDD_X5_X1_X6_X0_M4_d N_34_X5_X1_X6_X0_M4_g
+ N_X5_X1_X6_X0_6_X5_X1_X6_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X6_X0_M5 N_X5_X1_26_X5_X1_X6_X0_M5_d N_X5_X1_X6_X0_6_X5_X1_X6_X0_M5_g
+ N_VDD_X5_X1_X6_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X6_X1_M0 X5_X1_X6_X1_7 N_24_X5_X1_X6_X1_M0_g
+ N_X5_X1_X6_X1_6_X5_X1_X6_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX5_X1_X6_X1_M1 N_GROUND_X5_X1_X6_X1_M1_d N_34_X5_X1_X6_X1_M1_g X5_X1_X6_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX5_X1_X6_X1_M2 N_X5_X1_27_X5_X1_X6_X1_M2_d N_X5_X1_X6_X1_6_X5_X1_X6_X1_M2_g
+ N_GROUND_X5_X1_X6_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X6_X1_M3 N_X5_X1_X6_X1_6_X5_X1_X6_X1_M3_d N_24_X5_X1_X6_X1_M3_g
+ N_VDD_X5_X1_X6_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X6_X1_M4 N_VDD_X5_X1_X6_X1_M4_d N_34_X5_X1_X6_X1_M4_g
+ N_X5_X1_X6_X1_6_X5_X1_X6_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X6_X1_M5 N_X5_X1_27_X5_X1_X6_X1_M5_d N_X5_X1_X6_X1_6_X5_X1_X6_X1_M5_g
+ N_VDD_X5_X1_X6_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X7_X0_M0 X5_X1_X7_X0_7 N_25_X5_X1_X7_X0_M0_g
+ N_X5_X1_X7_X0_6_X5_X1_X7_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX5_X1_X7_X0_M1 N_GROUND_X5_X1_X7_X0_M1_d N_34_X5_X1_X7_X0_M1_g X5_X1_X7_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX5_X1_X7_X0_M2 N_X5_X1_28_X5_X1_X7_X0_M2_d N_X5_X1_X7_X0_6_X5_X1_X7_X0_M2_g
+ N_GROUND_X5_X1_X7_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X7_X0_M3 N_X5_X1_X7_X0_6_X5_X1_X7_X0_M3_d N_25_X5_X1_X7_X0_M3_g
+ N_VDD_X5_X1_X7_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X7_X0_M4 N_VDD_X5_X1_X7_X0_M4_d N_34_X5_X1_X7_X0_M4_g
+ N_X5_X1_X7_X0_6_X5_X1_X7_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X7_X0_M5 N_X5_X1_28_X5_X1_X7_X0_M5_d N_X5_X1_X7_X0_6_X5_X1_X7_X0_M5_g
+ N_VDD_X5_X1_X7_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X7_X1_M0 X5_X1_X7_X1_7 N_26_X5_X1_X7_X1_M0_g
+ N_X5_X1_X7_X1_6_X5_X1_X7_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX5_X1_X7_X1_M1 N_GROUND_X5_X1_X7_X1_M1_d N_34_X5_X1_X7_X1_M1_g X5_X1_X7_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX5_X1_X7_X1_M2 N_X5_X1_29_X5_X1_X7_X1_M2_d N_X5_X1_X7_X1_6_X5_X1_X7_X1_M2_g
+ N_GROUND_X5_X1_X7_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X7_X1_M3 N_X5_X1_X7_X1_6_X5_X1_X7_X1_M3_d N_26_X5_X1_X7_X1_M3_g
+ N_VDD_X5_X1_X7_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X7_X1_M4 N_VDD_X5_X1_X7_X1_M4_d N_34_X5_X1_X7_X1_M4_g
+ N_X5_X1_X7_X1_6_X5_X1_X7_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X7_X1_M5 N_X5_X1_29_X5_X1_X7_X1_M5_d N_X5_X1_X7_X1_6_X5_X1_X7_X1_M5_g
+ N_VDD_X5_X1_X7_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X0_M0 N_X5_X1_X8_15_X5_X1_X8_X0_M0_d N_X5_X1_X8_X0_7_X5_X1_X8_X0_M0_g
+ N_X5_X1_30_X5_X1_X8_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X0_M1 N_X5_X1_31_X5_X1_X8_X0_M1_d N_RS0_X5_X1_X8_X0_M1_g
+ N_X5_X1_X8_15_X5_X1_X8_X0_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X0_M2 N_X5_X1_X8_X0_7_X5_X1_X8_X0_M2_d N_RS0_X5_X1_X8_X0_M2_g
+ N_GROUND_X5_X1_X8_X0_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X0_M3 N_X5_X1_X8_15_X5_X1_X8_X0_M3_d N_RS0_X5_X1_X8_X0_M3_g
+ N_X5_X1_30_X5_X1_X8_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X0_M4 N_X5_X1_31_X5_X1_X8_X0_M4_d N_X5_X1_X8_X0_7_X5_X1_X8_X0_M4_g
+ N_X5_X1_X8_15_X5_X1_X8_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X0_M5 N_X5_X1_X8_X0_7_X5_X1_X8_X0_M5_d N_RS0_X5_X1_X8_X0_M5_g
+ N_VDD_X5_X1_X8_X0_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X1_M0 N_X5_X1_X8_16_X5_X1_X8_X1_M0_d N_X5_X1_X8_X1_7_X5_X1_X8_X1_M0_g
+ N_X5_X1_32_X5_X1_X8_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X1_M1 N_X5_X1_33_X5_X1_X8_X1_M1_d N_RS0_X5_X1_X8_X1_M1_g
+ N_X5_X1_X8_16_X5_X1_X8_X1_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X1_M2 N_X5_X1_X8_X1_7_X5_X1_X8_X1_M2_d N_RS0_X5_X1_X8_X1_M2_g
+ N_GROUND_X5_X1_X8_X1_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X1_M3 N_X5_X1_X8_16_X5_X1_X8_X1_M3_d N_RS0_X5_X1_X8_X1_M3_g
+ N_X5_X1_32_X5_X1_X8_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X1_M4 N_X5_X1_33_X5_X1_X8_X1_M4_d N_X5_X1_X8_X1_7_X5_X1_X8_X1_M4_g
+ N_X5_X1_X8_16_X5_X1_X8_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X1_M5 N_X5_X1_X8_X1_7_X5_X1_X8_X1_M5_d N_RS0_X5_X1_X8_X1_M5_g
+ N_VDD_X5_X1_X8_X1_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X2_M0 N_X5_X1_X8_19_X5_X1_X8_X2_M0_d N_X5_X1_X8_X2_7_X5_X1_X8_X2_M0_g
+ N_X5_X1_X8_15_X5_X1_X8_X2_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X2_M1 N_X5_X1_X8_16_X5_X1_X8_X2_M1_d N_RS1_X5_X1_X8_X2_M1_g
+ N_X5_X1_X8_19_X5_X1_X8_X2_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X2_M2 N_X5_X1_X8_X2_7_X5_X1_X8_X2_M2_d N_RS1_X5_X1_X8_X2_M2_g
+ N_GROUND_X5_X1_X8_X2_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X2_M3 N_X5_X1_X8_19_X5_X1_X8_X2_M3_d N_RS1_X5_X1_X8_X2_M3_g
+ N_X5_X1_X8_15_X5_X1_X8_X2_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X2_M4 N_X5_X1_X8_16_X5_X1_X8_X2_M4_d N_X5_X1_X8_X2_7_X5_X1_X8_X2_M4_g
+ N_X5_X1_X8_19_X5_X1_X8_X2_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X2_M5 N_X5_X1_X8_X2_7_X5_X1_X8_X2_M5_d N_RS1_X5_X1_X8_X2_M5_g
+ N_VDD_X5_X1_X8_X2_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X3_M0 N_X5_X1_X8_17_X5_X1_X8_X3_M0_d N_X5_X1_X8_X3_7_X5_X1_X8_X3_M0_g
+ N_X5_X1_34_X5_X1_X8_X3_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X3_M1 N_X5_X1_35_X5_X1_X8_X3_M1_d N_RS0_X5_X1_X8_X3_M1_g
+ N_X5_X1_X8_17_X5_X1_X8_X3_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X3_M2 N_X5_X1_X8_X3_7_X5_X1_X8_X3_M2_d N_RS0_X5_X1_X8_X3_M2_g
+ N_GROUND_X5_X1_X8_X3_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X3_M3 N_X5_X1_X8_17_X5_X1_X8_X3_M3_d N_RS0_X5_X1_X8_X3_M3_g
+ N_X5_X1_34_X5_X1_X8_X3_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X3_M4 N_X5_X1_35_X5_X1_X8_X3_M4_d N_X5_X1_X8_X3_7_X5_X1_X8_X3_M4_g
+ N_X5_X1_X8_17_X5_X1_X8_X3_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X3_M5 N_X5_X1_X8_X3_7_X5_X1_X8_X3_M5_d N_RS0_X5_X1_X8_X3_M5_g
+ N_VDD_X5_X1_X8_X3_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X4_M0 N_X5_X1_X8_18_X5_X1_X8_X4_M0_d N_X5_X1_X8_X4_7_X5_X1_X8_X4_M0_g
+ N_X5_X1_36_X5_X1_X8_X4_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X4_M1 N_X5_X1_37_X5_X1_X8_X4_M1_d N_RS0_X5_X1_X8_X4_M1_g
+ N_X5_X1_X8_18_X5_X1_X8_X4_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X4_M2 N_X5_X1_X8_X4_7_X5_X1_X8_X4_M2_d N_RS0_X5_X1_X8_X4_M2_g
+ N_GROUND_X5_X1_X8_X4_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X4_M3 N_X5_X1_X8_18_X5_X1_X8_X4_M3_d N_RS0_X5_X1_X8_X4_M3_g
+ N_X5_X1_36_X5_X1_X8_X4_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X4_M4 N_X5_X1_37_X5_X1_X8_X4_M4_d N_X5_X1_X8_X4_7_X5_X1_X8_X4_M4_g
+ N_X5_X1_X8_18_X5_X1_X8_X4_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X4_M5 N_X5_X1_X8_X4_7_X5_X1_X8_X4_M5_d N_RS0_X5_X1_X8_X4_M5_g
+ N_VDD_X5_X1_X8_X4_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X5_M0 N_X5_X1_X8_20_X5_X1_X8_X5_M0_d N_X5_X1_X8_X5_7_X5_X1_X8_X5_M0_g
+ N_X5_X1_X8_17_X5_X1_X8_X5_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X5_M1 N_X5_X1_X8_18_X5_X1_X8_X5_M1_d N_RS1_X5_X1_X8_X5_M1_g
+ N_X5_X1_X8_20_X5_X1_X8_X5_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X5_M2 N_X5_X1_X8_X5_7_X5_X1_X8_X5_M2_d N_RS1_X5_X1_X8_X5_M2_g
+ N_GROUND_X5_X1_X8_X5_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X5_M3 N_X5_X1_X8_20_X5_X1_X8_X5_M3_d N_RS1_X5_X1_X8_X5_M3_g
+ N_X5_X1_X8_17_X5_X1_X8_X5_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X5_M4 N_X5_X1_X8_18_X5_X1_X8_X5_M4_d N_X5_X1_X8_X5_7_X5_X1_X8_X5_M4_g
+ N_X5_X1_X8_20_X5_X1_X8_X5_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X5_M5 N_X5_X1_X8_X5_7_X5_X1_X8_X5_M5_d N_RS1_X5_X1_X8_X5_M5_g
+ N_VDD_X5_X1_X8_X5_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X6_M0 N_X5_47_X5_X1_X8_X6_M0_d N_X5_X1_X8_X6_7_X5_X1_X8_X6_M0_g
+ N_X5_X1_X8_19_X5_X1_X8_X6_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X6_M1 N_X5_X1_X8_20_X5_X1_X8_X6_M1_d N_RS2_X5_X1_X8_X6_M1_g
+ N_X5_47_X5_X1_X8_X6_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X6_M2 N_X5_X1_X8_X6_7_X5_X1_X8_X6_M2_d N_RS2_X5_X1_X8_X6_M2_g
+ N_GROUND_X5_X1_X8_X6_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X8_X6_M3 N_X5_47_X5_X1_X8_X6_M3_d N_RS2_X5_X1_X8_X6_M3_g
+ N_X5_X1_X8_19_X5_X1_X8_X6_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X6_M4 N_X5_X1_X8_20_X5_X1_X8_X6_M4_d N_X5_X1_X8_X6_7_X5_X1_X8_X6_M4_g
+ N_X5_47_X5_X1_X8_X6_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X8_X6_M5 N_X5_X1_X8_X6_7_X5_X1_X8_X6_M5_d N_RS2_X5_X1_X8_X6_M5_g
+ N_VDD_X5_X1_X8_X6_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X0_M0 N_X5_X1_X9_15_X5_X1_X9_X0_M0_d N_X5_X1_X9_X0_7_X5_X1_X9_X0_M0_g
+ N_X5_X1_30_X5_X1_X9_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X0_M1 N_X5_X1_31_X5_X1_X9_X0_M1_d N_RT0_X5_X1_X9_X0_M1_g
+ N_X5_X1_X9_15_X5_X1_X9_X0_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X0_M2 N_X5_X1_X9_X0_7_X5_X1_X9_X0_M2_d N_RT0_X5_X1_X9_X0_M2_g
+ N_GROUND_X5_X1_X9_X0_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X0_M3 N_X5_X1_X9_15_X5_X1_X9_X0_M3_d N_RT0_X5_X1_X9_X0_M3_g
+ N_X5_X1_30_X5_X1_X9_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X0_M4 N_X5_X1_31_X5_X1_X9_X0_M4_d N_X5_X1_X9_X0_7_X5_X1_X9_X0_M4_g
+ N_X5_X1_X9_15_X5_X1_X9_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X0_M5 N_X5_X1_X9_X0_7_X5_X1_X9_X0_M5_d N_RT0_X5_X1_X9_X0_M5_g
+ N_VDD_X5_X1_X9_X0_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X1_M0 N_X5_X1_X9_16_X5_X1_X9_X1_M0_d N_X5_X1_X9_X1_7_X5_X1_X9_X1_M0_g
+ N_X5_X1_32_X5_X1_X9_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X1_M1 N_X5_X1_33_X5_X1_X9_X1_M1_d N_RT0_X5_X1_X9_X1_M1_g
+ N_X5_X1_X9_16_X5_X1_X9_X1_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X1_M2 N_X5_X1_X9_X1_7_X5_X1_X9_X1_M2_d N_RT0_X5_X1_X9_X1_M2_g
+ N_GROUND_X5_X1_X9_X1_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X1_M3 N_X5_X1_X9_16_X5_X1_X9_X1_M3_d N_RT0_X5_X1_X9_X1_M3_g
+ N_X5_X1_32_X5_X1_X9_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X1_M4 N_X5_X1_33_X5_X1_X9_X1_M4_d N_X5_X1_X9_X1_7_X5_X1_X9_X1_M4_g
+ N_X5_X1_X9_16_X5_X1_X9_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X1_M5 N_X5_X1_X9_X1_7_X5_X1_X9_X1_M5_d N_RT0_X5_X1_X9_X1_M5_g
+ N_VDD_X5_X1_X9_X1_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X2_M0 N_X5_X1_X9_19_X5_X1_X9_X2_M0_d N_X5_X1_X9_X2_7_X5_X1_X9_X2_M0_g
+ N_X5_X1_X9_15_X5_X1_X9_X2_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X2_M1 N_X5_X1_X9_16_X5_X1_X9_X2_M1_d N_RT1_X5_X1_X9_X2_M1_g
+ N_X5_X1_X9_19_X5_X1_X9_X2_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X2_M2 N_X5_X1_X9_X2_7_X5_X1_X9_X2_M2_d N_RT1_X5_X1_X9_X2_M2_g
+ N_GROUND_X5_X1_X9_X2_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X2_M3 N_X5_X1_X9_19_X5_X1_X9_X2_M3_d N_RT1_X5_X1_X9_X2_M3_g
+ N_X5_X1_X9_15_X5_X1_X9_X2_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X2_M4 N_X5_X1_X9_16_X5_X1_X9_X2_M4_d N_X5_X1_X9_X2_7_X5_X1_X9_X2_M4_g
+ N_X5_X1_X9_19_X5_X1_X9_X2_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X2_M5 N_X5_X1_X9_X2_7_X5_X1_X9_X2_M5_d N_RT1_X5_X1_X9_X2_M5_g
+ N_VDD_X5_X1_X9_X2_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X3_M0 N_X5_X1_X9_17_X5_X1_X9_X3_M0_d N_X5_X1_X9_X3_7_X5_X1_X9_X3_M0_g
+ N_X5_X1_34_X5_X1_X9_X3_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X3_M1 N_X5_X1_35_X5_X1_X9_X3_M1_d N_RT0_X5_X1_X9_X3_M1_g
+ N_X5_X1_X9_17_X5_X1_X9_X3_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X3_M2 N_X5_X1_X9_X3_7_X5_X1_X9_X3_M2_d N_RT0_X5_X1_X9_X3_M2_g
+ N_GROUND_X5_X1_X9_X3_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X3_M3 N_X5_X1_X9_17_X5_X1_X9_X3_M3_d N_RT0_X5_X1_X9_X3_M3_g
+ N_X5_X1_34_X5_X1_X9_X3_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X3_M4 N_X5_X1_35_X5_X1_X9_X3_M4_d N_X5_X1_X9_X3_7_X5_X1_X9_X3_M4_g
+ N_X5_X1_X9_17_X5_X1_X9_X3_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X3_M5 N_X5_X1_X9_X3_7_X5_X1_X9_X3_M5_d N_RT0_X5_X1_X9_X3_M5_g
+ N_VDD_X5_X1_X9_X3_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X4_M0 N_X5_X1_X9_18_X5_X1_X9_X4_M0_d N_X5_X1_X9_X4_7_X5_X1_X9_X4_M0_g
+ N_X5_X1_36_X5_X1_X9_X4_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X4_M1 N_X5_X1_37_X5_X1_X9_X4_M1_d N_RT0_X5_X1_X9_X4_M1_g
+ N_X5_X1_X9_18_X5_X1_X9_X4_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X4_M2 N_X5_X1_X9_X4_7_X5_X1_X9_X4_M2_d N_RT0_X5_X1_X9_X4_M2_g
+ N_GROUND_X5_X1_X9_X4_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X4_M3 N_X5_X1_X9_18_X5_X1_X9_X4_M3_d N_RT0_X5_X1_X9_X4_M3_g
+ N_X5_X1_36_X5_X1_X9_X4_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X4_M4 N_X5_X1_37_X5_X1_X9_X4_M4_d N_X5_X1_X9_X4_7_X5_X1_X9_X4_M4_g
+ N_X5_X1_X9_18_X5_X1_X9_X4_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X4_M5 N_X5_X1_X9_X4_7_X5_X1_X9_X4_M5_d N_RT0_X5_X1_X9_X4_M5_g
+ N_VDD_X5_X1_X9_X4_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X5_M0 N_X5_X1_X9_20_X5_X1_X9_X5_M0_d N_X5_X1_X9_X5_7_X5_X1_X9_X5_M0_g
+ N_X5_X1_X9_17_X5_X1_X9_X5_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X5_M1 N_X5_X1_X9_18_X5_X1_X9_X5_M1_d N_RT1_X5_X1_X9_X5_M1_g
+ N_X5_X1_X9_20_X5_X1_X9_X5_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X5_M2 N_X5_X1_X9_X5_7_X5_X1_X9_X5_M2_d N_RT1_X5_X1_X9_X5_M2_g
+ N_GROUND_X5_X1_X9_X5_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X5_M3 N_X5_X1_X9_20_X5_X1_X9_X5_M3_d N_RT1_X5_X1_X9_X5_M3_g
+ N_X5_X1_X9_17_X5_X1_X9_X5_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X5_M4 N_X5_X1_X9_18_X5_X1_X9_X5_M4_d N_X5_X1_X9_X5_7_X5_X1_X9_X5_M4_g
+ N_X5_X1_X9_20_X5_X1_X9_X5_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X5_M5 N_X5_X1_X9_X5_7_X5_X1_X9_X5_M5_d N_RT1_X5_X1_X9_X5_M5_g
+ N_VDD_X5_X1_X9_X5_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X6_M0 N_X5_48_X5_X1_X9_X6_M0_d N_X5_X1_X9_X6_7_X5_X1_X9_X6_M0_g
+ N_X5_X1_X9_19_X5_X1_X9_X6_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X6_M1 N_X5_X1_X9_20_X5_X1_X9_X6_M1_d N_RT2_X5_X1_X9_X6_M1_g
+ N_X5_48_X5_X1_X9_X6_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X6_M2 N_X5_X1_X9_X6_7_X5_X1_X9_X6_M2_d N_RT2_X5_X1_X9_X6_M2_g
+ N_GROUND_X5_X1_X9_X6_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX5_X1_X9_X6_M3 N_X5_48_X5_X1_X9_X6_M3_d N_RT2_X5_X1_X9_X6_M3_g
+ N_X5_X1_X9_19_X5_X1_X9_X6_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X6_M4 N_X5_X1_X9_20_X5_X1_X9_X6_M4_d N_X5_X1_X9_X6_7_X5_X1_X9_X6_M4_g
+ N_X5_48_X5_X1_X9_X6_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX5_X1_X9_X6_M5 N_X5_X1_X9_X6_7_X5_X1_X9_X6_M5_d N_RT2_X5_X1_X9_X6_M5_g
+ N_VDD_X5_X1_X9_X6_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_M0 X6_X0_11 N_40_X6_X0_M0_g N_X6_X0_10_X6_X0_M0_s N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=2e-06
mX6_X0_M1 X6_X0_12 N_X6_X0_23_X6_X0_M1_g X6_X0_11 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=2e-06
mX6_X0_M2 N_GROUND_X6_X0_M2_d N_X6_47_X6_X0_M2_g X6_X0_12 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=2e-06
mX6_X0_M3 N_28_X6_X0_M3_d N_X6_X0_16_X6_X0_M3_g N_GROUND_X6_X0_M2_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX6_X0_M4 N_GROUND_X6_X0_M4_d N_X6_X0_10_X6_X0_M4_g N_X6_X0_13_X6_X0_M4_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX6_X0_M5 N_X6_X0_14_X6_X0_M5_d N_40_X6_X0_M5_g N_GROUND_X6_X0_M4_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX6_X0_M6 N_GROUND_X6_X0_M6_d N_X6_X0_23_X6_X0_M6_g N_X6_X0_14_X6_X0_M5_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX6_X0_M7 N_X6_X0_14_X6_X0_M7_d N_X6_47_X6_X0_M7_g N_GROUND_X6_X0_M6_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX6_X0_M8 N_X6_X0_10_X6_X0_M8_d N_X6_X0_16_X6_X0_M8_g N_X6_X0_14_X6_X0_M7_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX6_X0_M9 N_X6_X0_15_X6_X0_M9_d N_X6_X0_23_X6_X0_M9_g N_GROUND_X6_X0_M9_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX6_X0_M10 N_X6_X0_16_X6_X0_M10_d N_40_X6_X0_M10_g N_X6_X0_15_X6_X0_M9_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX6_X0_M11 X6_X0_17 N_X6_47_X6_X0_M11_g N_X6_X0_16_X6_X0_M10_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=2e-06
mX6_X0_M12 N_GROUND_X6_X0_M12_d N_X6_X0_23_X6_X0_M12_g X6_X0_17 N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=2e-06
mX6_X0_M13 N_X6_X0_15_X6_X0_M13_d N_X6_47_X6_X0_M13_g N_GROUND_X6_X0_M12_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX6_X0_M14 N_X6_X0_16_X6_X0_M14_d N_40_X6_X0_M14_g N_X6_X0_18_X6_X0_M14_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX6_X0_M15 X6_X0_19 N_X6_47_X6_X0_M15_g N_X6_X0_16_X6_X0_M14_d N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=2e-06
mX6_X0_M16 N_VDD_X6_X0_M16_d N_X6_X0_23_X6_X0_M16_g X6_X0_19 N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=2e-06
mX6_X0_M17 N_X6_X0_18_X6_X0_M17_d N_X6_X0_23_X6_X0_M17_g N_VDD_X6_X0_M16_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX6_X0_M18 N_VDD_X6_X0_M18_d N_X6_47_X6_X0_M18_g N_X6_X0_18_X6_X0_M17_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX6_X0_M19 X6_X0_20 N_X6_47_X6_X0_M19_g N_VDD_X6_X0_M18_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=2e-06
mX6_X0_M20 X6_X0_21 N_X6_X0_23_X6_X0_M20_g X6_X0_20 N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=2e-06
mX6_X0_M21 N_X6_X0_10_X6_X0_M21_d N_40_X6_X0_M21_g X6_X0_21 N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=2e-06
mX6_X0_M22 N_X6_X0_22_X6_X0_M22_d N_X6_X0_16_X6_X0_M22_g N_X6_X0_10_X6_X0_M21_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX6_X0_M23 N_VDD_X6_X0_M23_d N_X6_X0_16_X6_X0_M23_g N_28_X6_X0_M23_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX6_X0_M24 N_X6_X0_22_X6_X0_M24_d N_X6_47_X6_X0_M24_g N_VDD_X6_X0_M23_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX6_X0_M25 N_VDD_X6_X0_M25_d N_X6_X0_23_X6_X0_M25_g N_X6_X0_22_X6_X0_M24_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX6_X0_M26 N_X6_X0_22_X6_X0_M26_d N_40_X6_X0_M26_g N_VDD_X6_X0_M25_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX6_X0_M27 N_X6_X0_13_X6_X0_M27_d N_X6_X0_10_X6_X0_M27_g N_VDD_X6_X0_M27_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX6_X0_X28_M0 N_X6_X0_X28_6_X6_X0_X28_M0_d N_X6_48_X6_X0_X28_M0_g
+ N_GROUND_X6_X0_X28_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_X28_M1 N_GROUND_X6_X0_X28_M1_d N_X6_47_X6_X0_X28_M1_g
+ N_X6_X0_X28_6_X6_X0_X28_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_X28_M2 N_X6_X0_24_X6_X0_X28_M2_d N_X6_X0_X28_6_X6_X0_X28_M2_g
+ N_GROUND_X6_X0_X28_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_X28_M3 N_VDD_X6_X0_X28_M3_d N_X6_X0_X28_6_X6_X0_X28_M3_g
+ N_X6_X0_24_X6_X0_X28_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_X28_M4 X6_X0_X28_7 N_X6_47_X6_X0_X28_M4_g N_VDD_X6_X0_X28_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX6_X0_X28_M5 N_X6_X0_X28_6_X6_X0_X28_M5_d N_X6_48_X6_X0_X28_M5_g X6_X0_X28_7
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX6_X0_X29_M0 N_X6_X0_25_X6_X0_X29_M0_d N_X6_48_X6_X0_X29_M0_g
+ N_GROUND_X6_X0_X29_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_X29_M1 N_X6_X0_25_X6_X0_X29_M1_d N_X6_48_X6_X0_X29_M1_g
+ N_VDD_X6_X0_X29_M1_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_X30_M0 N_X6_X0_23_X6_X0_X30_M0_d N_X6_X0_X30_7_X6_X0_X30_M0_g
+ N_X6_48_X6_X0_X30_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_X30_M1 N_X6_X0_25_X6_X0_X30_M1_d N_29_X6_X0_X30_M1_g
+ N_X6_X0_23_X6_X0_X30_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_X30_M2 N_X6_X0_X30_7_X6_X0_X30_M2_d N_29_X6_X0_X30_M2_g
+ N_GROUND_X6_X0_X30_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_X30_M3 N_X6_X0_23_X6_X0_X30_M3_d N_29_X6_X0_X30_M3_g
+ N_X6_48_X6_X0_X30_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_X30_M4 N_X6_X0_25_X6_X0_X30_M4_d N_X6_X0_X30_7_X6_X0_X30_M4_g
+ N_X6_X0_23_X6_X0_X30_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_X30_M5 N_X6_X0_X30_7_X6_X0_X30_M5_d N_29_X6_X0_X30_M5_g
+ N_VDD_X6_X0_X30_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_X31_M0 N_X6_X0_27_X6_X0_X31_M0_d N_X6_X0_X31_7_X6_X0_X31_M0_g
+ N_X6_X0_13_X6_X0_X31_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_X31_M1 N_X6_X0_13_X6_X0_X31_M1_d N_29_X6_X0_X31_M1_g
+ N_X6_X0_27_X6_X0_X31_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_X31_M2 N_X6_X0_X31_7_X6_X0_X31_M2_d N_29_X6_X0_X31_M2_g
+ N_GROUND_X6_X0_X31_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_X31_M3 N_X6_X0_27_X6_X0_X31_M3_d N_29_X6_X0_X31_M3_g
+ N_X6_X0_13_X6_X0_X31_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_X31_M4 N_X6_X0_13_X6_X0_X31_M4_d N_X6_X0_X31_7_X6_X0_X31_M4_g
+ N_X6_X0_27_X6_X0_X31_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_X31_M5 N_X6_X0_X31_7_X6_X0_X31_M5_d N_29_X6_X0_X31_M5_g
+ N_VDD_X6_X0_X31_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_X32_M0 N_RESULT2_X6_X0_X32_M0_d N_X6_X0_X32_7_X6_X0_X32_M0_g
+ N_X6_X0_27_X6_X0_X32_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_X32_M1 N_X6_X0_28_X6_X0_X32_M1_d N_30_X6_X0_X32_M1_g
+ N_RESULT2_X6_X0_X32_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_X32_M2 N_X6_X0_X32_7_X6_X0_X32_M2_d N_30_X6_X0_X32_M2_g
+ N_GROUND_X6_X0_X32_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_X32_M3 N_RESULT2_X6_X0_X32_M3_d N_30_X6_X0_X32_M3_g
+ N_X6_X0_27_X6_X0_X32_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_X32_M4 N_X6_X0_28_X6_X0_X32_M4_d N_X6_X0_X32_7_X6_X0_X32_M4_g
+ N_RESULT2_X6_X0_X32_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_X32_M5 N_X6_X0_X32_7_X6_X0_X32_M5_d N_30_X6_X0_X32_M5_g
+ N_VDD_X6_X0_X32_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_X33_M0 N_X6_X0_28_X6_X0_X33_M0_d N_X6_X0_X33_7_X6_X0_X33_M0_g
+ N_X6_X0_26_X6_X0_X33_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_X33_M1 N_X6_X0_24_X6_X0_X33_M1_d N_29_X6_X0_X33_M1_g
+ N_X6_X0_28_X6_X0_X33_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_X33_M2 N_X6_X0_X33_7_X6_X0_X33_M2_d N_29_X6_X0_X33_M2_g
+ N_GROUND_X6_X0_X33_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_X33_M3 N_X6_X0_28_X6_X0_X33_M3_d N_29_X6_X0_X33_M3_g
+ N_X6_X0_26_X6_X0_X33_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_X33_M4 N_X6_X0_24_X6_X0_X33_M4_d N_X6_X0_X33_7_X6_X0_X33_M4_g
+ N_X6_X0_28_X6_X0_X33_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_X33_M5 N_X6_X0_X33_7_X6_X0_X33_M5_d N_29_X6_X0_X33_M5_g
+ N_VDD_X6_X0_X33_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_X34_M0 X6_X0_X34_7 N_X6_47_X6_X0_X34_M0_g N_X6_X0_X34_6_X6_X0_X34_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX6_X0_X34_M1 N_GROUND_X6_X0_X34_M1_d N_X6_48_X6_X0_X34_M1_g X6_X0_X34_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX6_X0_X34_M2 N_X6_X0_26_X6_X0_X34_M2_d N_X6_X0_X34_6_X6_X0_X34_M2_g
+ N_GROUND_X6_X0_X34_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X0_X34_M3 N_X6_X0_X34_6_X6_X0_X34_M3_d N_X6_47_X6_X0_X34_M3_g
+ N_VDD_X6_X0_X34_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_X34_M4 N_VDD_X6_X0_X34_M4_d N_X6_48_X6_X0_X34_M4_g
+ N_X6_X0_X34_6_X6_X0_X34_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X0_X34_M5 N_X6_X0_26_X6_X0_X34_M5_d N_X6_X0_X34_6_X6_X0_X34_M5_g
+ N_VDD_X6_X0_X34_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X0_X0_M0 N_GROUND_X6_X1_X0_X0_M0_d N_X6_X1_X0_X0_11_X6_X1_X0_X0_M0_g
+ N_X6_X1_30_X6_X1_X0_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M1 N_X6_X1_X0_X0_7_X6_X1_X0_X0_M1_d
+ N_X6_X1_X0_X0_10_X6_X1_X0_X0_M1_g N_GROUND_X6_X1_X0_X0_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M2 X6_X1_X0_X0_8 N_X6_X1_X0_X0_15_X6_X1_X0_X0_M2_g
+ N_X6_X1_X0_X0_7_X6_X1_X0_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M3 N_GROUND_X6_X1_X0_X0_M3_d N_X6_X1_X0_X0_16_X6_X1_X0_X0_M3_g
+ X6_X1_X0_X0_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M4 X6_X1_X0_X0_9 N_X6_X1_X0_X0_14_X6_X1_X0_X0_M4_g
+ N_GROUND_X6_X1_X0_X0_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M5 N_X6_X1_X0_X0_10_X6_X1_X0_X0_M5_d
+ N_X6_X1_X0_X0_15_X6_X1_X0_X0_M5_g X6_X1_X0_X0_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M6 N_GROUND_X6_X1_X0_X0_M6_d N_X6_X1_X0_X0_7_X6_X1_X0_X0_M6_g
+ N_X6_X1_X0_X0_10_X6_X1_X0_X0_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M7 N_X6_X1_X0_X0_11_X6_X1_X0_X0_M7_d N_X6_X1_30_X6_X1_X0_X0_M7_g
+ N_GROUND_X6_X1_X0_X0_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M8 X6_X1_X0_X0_12 N_CLK_X6_X1_X0_X0_M8_g
+ N_X6_X1_X0_X0_11_X6_X1_X0_X0_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M9 N_GROUND_X6_X1_X0_X0_M9_d N_X6_X1_X0_X0_10_X6_X1_X0_X0_M9_g
+ X6_X1_X0_X0_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M10 X6_X1_X0_X0_13 N_X6_X1_X0_X0_7_X6_X1_X0_X0_M10_g
+ N_GROUND_X6_X1_X0_X0_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M11 N_X6_X1_30_X6_X1_X0_X0_M11_d N_CLK_X6_X1_X0_X0_M11_g
+ X6_X1_X0_X0_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M12 N_GROUND_X6_X1_X0_X0_M12_d N_X6_X1_X0_X0_16_X6_X1_X0_X0_M12_g
+ N_X6_X1_X0_X0_14_X6_X1_X0_X0_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M13 N_X6_X1_X0_X0_15_X6_X1_X0_X0_M13_d N_CLK_X6_X1_X0_X0_M13_g
+ N_GROUND_X6_X1_X0_X0_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M14 N_VDD_X6_X1_X0_X0_M14_d N_X6_X1_X0_X0_16_X6_X1_X0_X0_M14_g
+ N_X6_X1_X0_X0_14_X6_X1_X0_X0_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M15 N_X6_X1_X0_X0_15_X6_X1_X0_X0_M15_d N_CLK_X6_X1_X0_X0_M15_g
+ N_VDD_X6_X1_X0_X0_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M16 N_VDD_X6_X1_X0_X0_M16_d N_X6_X1_X0_X0_7_X6_X1_X0_X0_M16_g
+ N_X6_X1_X0_X0_10_X6_X1_X0_X0_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M17 N_X6_X1_X0_X0_7_X6_X1_X0_X0_M17_d
+ N_X6_X1_X0_X0_10_X6_X1_X0_X0_M17_g N_VDD_X6_X1_X0_X0_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M18 N_VDD_X6_X1_X0_X0_M18_d N_X6_X1_X0_X0_11_X6_X1_X0_X0_M18_g
+ N_X6_X1_30_X6_X1_X0_X0_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_M19 N_X6_X1_X0_X0_11_X6_X1_X0_X0_M19_d N_X6_X1_30_X6_X1_X0_X0_M19_g
+ N_VDD_X6_X1_X0_X0_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_X20_M0 N_X6_X1_X0_X0_16_X6_X1_X0_X0_X20_M0_d
+ N_X6_X1_X0_X0_X20_7_X6_X1_X0_X0_X20_M0_g N_X6_X1_30_X6_X1_X0_X0_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_X20_M1 N_7_X6_X1_X0_X0_X20_M1_d N_X6_X1_22_X6_X1_X0_X0_X20_M1_g
+ N_X6_X1_X0_X0_16_X6_X1_X0_X0_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_X20_M2 N_X6_X1_X0_X0_X20_7_X6_X1_X0_X0_X20_M2_d
+ N_X6_X1_22_X6_X1_X0_X0_X20_M2_g N_GROUND_X6_X1_X0_X0_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X0_X20_M3 N_X6_X1_X0_X0_16_X6_X1_X0_X0_X20_M3_d
+ N_X6_X1_22_X6_X1_X0_X0_X20_M3_g N_X6_X1_30_X6_X1_X0_X0_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X0_X0_X20_M4 N_7_X6_X1_X0_X0_X20_M4_d
+ N_X6_X1_X0_X0_X20_7_X6_X1_X0_X0_X20_M4_g N_X6_X1_X0_X0_16_X6_X1_X0_X0_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X0_X0_X20_M5 N_X6_X1_X0_X0_X20_7_X6_X1_X0_X0_X20_M5_d
+ N_X6_X1_22_X6_X1_X0_X0_X20_M5_g N_VDD_X6_X1_X0_X0_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX6_X1_X0_X1_M0 N_GROUND_X6_X1_X0_X1_M0_d N_X6_X1_X0_X1_11_X6_X1_X0_X1_M0_g
+ N_X6_X1_31_X6_X1_X0_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M1 N_X6_X1_X0_X1_7_X6_X1_X0_X1_M1_d
+ N_X6_X1_X0_X1_10_X6_X1_X0_X1_M1_g N_GROUND_X6_X1_X0_X1_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M2 X6_X1_X0_X1_8 N_X6_X1_X0_X1_15_X6_X1_X0_X1_M2_g
+ N_X6_X1_X0_X1_7_X6_X1_X0_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M3 N_GROUND_X6_X1_X0_X1_M3_d N_X6_X1_X0_X1_16_X6_X1_X0_X1_M3_g
+ X6_X1_X0_X1_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M4 X6_X1_X0_X1_9 N_X6_X1_X0_X1_14_X6_X1_X0_X1_M4_g
+ N_GROUND_X6_X1_X0_X1_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M5 N_X6_X1_X0_X1_10_X6_X1_X0_X1_M5_d
+ N_X6_X1_X0_X1_15_X6_X1_X0_X1_M5_g X6_X1_X0_X1_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M6 N_GROUND_X6_X1_X0_X1_M6_d N_X6_X1_X0_X1_7_X6_X1_X0_X1_M6_g
+ N_X6_X1_X0_X1_10_X6_X1_X0_X1_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M7 N_X6_X1_X0_X1_11_X6_X1_X0_X1_M7_d N_X6_X1_31_X6_X1_X0_X1_M7_g
+ N_GROUND_X6_X1_X0_X1_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M8 X6_X1_X0_X1_12 N_CLK_X6_X1_X0_X1_M8_g
+ N_X6_X1_X0_X1_11_X6_X1_X0_X1_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M9 N_GROUND_X6_X1_X0_X1_M9_d N_X6_X1_X0_X1_10_X6_X1_X0_X1_M9_g
+ X6_X1_X0_X1_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M10 X6_X1_X0_X1_13 N_X6_X1_X0_X1_7_X6_X1_X0_X1_M10_g
+ N_GROUND_X6_X1_X0_X1_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M11 N_X6_X1_31_X6_X1_X0_X1_M11_d N_CLK_X6_X1_X0_X1_M11_g
+ X6_X1_X0_X1_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M12 N_GROUND_X6_X1_X0_X1_M12_d N_X6_X1_X0_X1_16_X6_X1_X0_X1_M12_g
+ N_X6_X1_X0_X1_14_X6_X1_X0_X1_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M13 N_X6_X1_X0_X1_15_X6_X1_X0_X1_M13_d N_CLK_X6_X1_X0_X1_M13_g
+ N_GROUND_X6_X1_X0_X1_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M14 N_VDD_X6_X1_X0_X1_M14_d N_X6_X1_X0_X1_16_X6_X1_X0_X1_M14_g
+ N_X6_X1_X0_X1_14_X6_X1_X0_X1_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M15 N_X6_X1_X0_X1_15_X6_X1_X0_X1_M15_d N_CLK_X6_X1_X0_X1_M15_g
+ N_VDD_X6_X1_X0_X1_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M16 N_VDD_X6_X1_X0_X1_M16_d N_X6_X1_X0_X1_7_X6_X1_X0_X1_M16_g
+ N_X6_X1_X0_X1_10_X6_X1_X0_X1_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M17 N_X6_X1_X0_X1_7_X6_X1_X0_X1_M17_d
+ N_X6_X1_X0_X1_10_X6_X1_X0_X1_M17_g N_VDD_X6_X1_X0_X1_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M18 N_VDD_X6_X1_X0_X1_M18_d N_X6_X1_X0_X1_11_X6_X1_X0_X1_M18_g
+ N_X6_X1_31_X6_X1_X0_X1_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_M19 N_X6_X1_X0_X1_11_X6_X1_X0_X1_M19_d N_X6_X1_31_X6_X1_X0_X1_M19_g
+ N_VDD_X6_X1_X0_X1_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_X20_M0 N_X6_X1_X0_X1_16_X6_X1_X0_X1_X20_M0_d
+ N_X6_X1_X0_X1_X20_7_X6_X1_X0_X1_X20_M0_g N_X6_X1_31_X6_X1_X0_X1_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_X20_M1 N_7_X6_X1_X0_X1_X20_M1_d N_X6_X1_23_X6_X1_X0_X1_X20_M1_g
+ N_X6_X1_X0_X1_16_X6_X1_X0_X1_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_X20_M2 N_X6_X1_X0_X1_X20_7_X6_X1_X0_X1_X20_M2_d
+ N_X6_X1_23_X6_X1_X0_X1_X20_M2_g N_GROUND_X6_X1_X0_X1_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX6_X1_X0_X1_X20_M3 N_X6_X1_X0_X1_16_X6_X1_X0_X1_X20_M3_d
+ N_X6_X1_23_X6_X1_X0_X1_X20_M3_g N_X6_X1_31_X6_X1_X0_X1_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X0_X1_X20_M4 N_7_X6_X1_X0_X1_X20_M4_d
+ N_X6_X1_X0_X1_X20_7_X6_X1_X0_X1_X20_M4_g N_X6_X1_X0_X1_16_X6_X1_X0_X1_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X0_X1_X20_M5 N_X6_X1_X0_X1_X20_7_X6_X1_X0_X1_X20_M5_d
+ N_X6_X1_23_X6_X1_X0_X1_X20_M5_g N_VDD_X6_X1_X0_X1_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX6_X1_X1_X0_M0 N_GROUND_X6_X1_X1_X0_M0_d N_X6_X1_X1_X0_11_X6_X1_X1_X0_M0_g
+ N_X6_X1_32_X6_X1_X1_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M1 N_X6_X1_X1_X0_7_X6_X1_X1_X0_M1_d
+ N_X6_X1_X1_X0_10_X6_X1_X1_X0_M1_g N_GROUND_X6_X1_X1_X0_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M2 X6_X1_X1_X0_8 N_X6_X1_X1_X0_15_X6_X1_X1_X0_M2_g
+ N_X6_X1_X1_X0_7_X6_X1_X1_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M3 N_GROUND_X6_X1_X1_X0_M3_d N_X6_X1_X1_X0_16_X6_X1_X1_X0_M3_g
+ X6_X1_X1_X0_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M4 X6_X1_X1_X0_9 N_X6_X1_X1_X0_14_X6_X1_X1_X0_M4_g
+ N_GROUND_X6_X1_X1_X0_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M5 N_X6_X1_X1_X0_10_X6_X1_X1_X0_M5_d
+ N_X6_X1_X1_X0_15_X6_X1_X1_X0_M5_g X6_X1_X1_X0_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M6 N_GROUND_X6_X1_X1_X0_M6_d N_X6_X1_X1_X0_7_X6_X1_X1_X0_M6_g
+ N_X6_X1_X1_X0_10_X6_X1_X1_X0_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M7 N_X6_X1_X1_X0_11_X6_X1_X1_X0_M7_d N_X6_X1_32_X6_X1_X1_X0_M7_g
+ N_GROUND_X6_X1_X1_X0_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M8 X6_X1_X1_X0_12 N_CLK_X6_X1_X1_X0_M8_g
+ N_X6_X1_X1_X0_11_X6_X1_X1_X0_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M9 N_GROUND_X6_X1_X1_X0_M9_d N_X6_X1_X1_X0_10_X6_X1_X1_X0_M9_g
+ X6_X1_X1_X0_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M10 X6_X1_X1_X0_13 N_X6_X1_X1_X0_7_X6_X1_X1_X0_M10_g
+ N_GROUND_X6_X1_X1_X0_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M11 N_X6_X1_32_X6_X1_X1_X0_M11_d N_CLK_X6_X1_X1_X0_M11_g
+ X6_X1_X1_X0_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M12 N_GROUND_X6_X1_X1_X0_M12_d N_X6_X1_X1_X0_16_X6_X1_X1_X0_M12_g
+ N_X6_X1_X1_X0_14_X6_X1_X1_X0_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M13 N_X6_X1_X1_X0_15_X6_X1_X1_X0_M13_d N_CLK_X6_X1_X1_X0_M13_g
+ N_GROUND_X6_X1_X1_X0_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M14 N_VDD_X6_X1_X1_X0_M14_d N_X6_X1_X1_X0_16_X6_X1_X1_X0_M14_g
+ N_X6_X1_X1_X0_14_X6_X1_X1_X0_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M15 N_X6_X1_X1_X0_15_X6_X1_X1_X0_M15_d N_CLK_X6_X1_X1_X0_M15_g
+ N_VDD_X6_X1_X1_X0_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M16 N_VDD_X6_X1_X1_X0_M16_d N_X6_X1_X1_X0_7_X6_X1_X1_X0_M16_g
+ N_X6_X1_X1_X0_10_X6_X1_X1_X0_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M17 N_X6_X1_X1_X0_7_X6_X1_X1_X0_M17_d
+ N_X6_X1_X1_X0_10_X6_X1_X1_X0_M17_g N_VDD_X6_X1_X1_X0_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M18 N_VDD_X6_X1_X1_X0_M18_d N_X6_X1_X1_X0_11_X6_X1_X1_X0_M18_g
+ N_X6_X1_32_X6_X1_X1_X0_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_M19 N_X6_X1_X1_X0_11_X6_X1_X1_X0_M19_d N_X6_X1_32_X6_X1_X1_X0_M19_g
+ N_VDD_X6_X1_X1_X0_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_X20_M0 N_X6_X1_X1_X0_16_X6_X1_X1_X0_X20_M0_d
+ N_X6_X1_X1_X0_X20_7_X6_X1_X1_X0_X20_M0_g N_X6_X1_32_X6_X1_X1_X0_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_X20_M1 N_7_X6_X1_X1_X0_X20_M1_d N_X6_X1_24_X6_X1_X1_X0_X20_M1_g
+ N_X6_X1_X1_X0_16_X6_X1_X1_X0_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_X20_M2 N_X6_X1_X1_X0_X20_7_X6_X1_X1_X0_X20_M2_d
+ N_X6_X1_24_X6_X1_X1_X0_X20_M2_g N_GROUND_X6_X1_X1_X0_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X0_X20_M3 N_X6_X1_X1_X0_16_X6_X1_X1_X0_X20_M3_d
+ N_X6_X1_24_X6_X1_X1_X0_X20_M3_g N_X6_X1_32_X6_X1_X1_X0_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X1_X0_X20_M4 N_7_X6_X1_X1_X0_X20_M4_d
+ N_X6_X1_X1_X0_X20_7_X6_X1_X1_X0_X20_M4_g N_X6_X1_X1_X0_16_X6_X1_X1_X0_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X1_X0_X20_M5 N_X6_X1_X1_X0_X20_7_X6_X1_X1_X0_X20_M5_d
+ N_X6_X1_24_X6_X1_X1_X0_X20_M5_g N_VDD_X6_X1_X1_X0_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX6_X1_X1_X1_M0 N_GROUND_X6_X1_X1_X1_M0_d N_X6_X1_X1_X1_11_X6_X1_X1_X1_M0_g
+ N_X6_X1_33_X6_X1_X1_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M1 N_X6_X1_X1_X1_7_X6_X1_X1_X1_M1_d
+ N_X6_X1_X1_X1_10_X6_X1_X1_X1_M1_g N_GROUND_X6_X1_X1_X1_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M2 X6_X1_X1_X1_8 N_X6_X1_X1_X1_15_X6_X1_X1_X1_M2_g
+ N_X6_X1_X1_X1_7_X6_X1_X1_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M3 N_GROUND_X6_X1_X1_X1_M3_d N_X6_X1_X1_X1_16_X6_X1_X1_X1_M3_g
+ X6_X1_X1_X1_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M4 X6_X1_X1_X1_9 N_X6_X1_X1_X1_14_X6_X1_X1_X1_M4_g
+ N_GROUND_X6_X1_X1_X1_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M5 N_X6_X1_X1_X1_10_X6_X1_X1_X1_M5_d
+ N_X6_X1_X1_X1_15_X6_X1_X1_X1_M5_g X6_X1_X1_X1_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M6 N_GROUND_X6_X1_X1_X1_M6_d N_X6_X1_X1_X1_7_X6_X1_X1_X1_M6_g
+ N_X6_X1_X1_X1_10_X6_X1_X1_X1_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M7 N_X6_X1_X1_X1_11_X6_X1_X1_X1_M7_d N_X6_X1_33_X6_X1_X1_X1_M7_g
+ N_GROUND_X6_X1_X1_X1_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M8 X6_X1_X1_X1_12 N_CLK_X6_X1_X1_X1_M8_g
+ N_X6_X1_X1_X1_11_X6_X1_X1_X1_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M9 N_GROUND_X6_X1_X1_X1_M9_d N_X6_X1_X1_X1_10_X6_X1_X1_X1_M9_g
+ X6_X1_X1_X1_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M10 X6_X1_X1_X1_13 N_X6_X1_X1_X1_7_X6_X1_X1_X1_M10_g
+ N_GROUND_X6_X1_X1_X1_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M11 N_X6_X1_33_X6_X1_X1_X1_M11_d N_CLK_X6_X1_X1_X1_M11_g
+ X6_X1_X1_X1_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M12 N_GROUND_X6_X1_X1_X1_M12_d N_X6_X1_X1_X1_16_X6_X1_X1_X1_M12_g
+ N_X6_X1_X1_X1_14_X6_X1_X1_X1_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M13 N_X6_X1_X1_X1_15_X6_X1_X1_X1_M13_d N_CLK_X6_X1_X1_X1_M13_g
+ N_GROUND_X6_X1_X1_X1_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M14 N_VDD_X6_X1_X1_X1_M14_d N_X6_X1_X1_X1_16_X6_X1_X1_X1_M14_g
+ N_X6_X1_X1_X1_14_X6_X1_X1_X1_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M15 N_X6_X1_X1_X1_15_X6_X1_X1_X1_M15_d N_CLK_X6_X1_X1_X1_M15_g
+ N_VDD_X6_X1_X1_X1_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M16 N_VDD_X6_X1_X1_X1_M16_d N_X6_X1_X1_X1_7_X6_X1_X1_X1_M16_g
+ N_X6_X1_X1_X1_10_X6_X1_X1_X1_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M17 N_X6_X1_X1_X1_7_X6_X1_X1_X1_M17_d
+ N_X6_X1_X1_X1_10_X6_X1_X1_X1_M17_g N_VDD_X6_X1_X1_X1_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M18 N_VDD_X6_X1_X1_X1_M18_d N_X6_X1_X1_X1_11_X6_X1_X1_X1_M18_g
+ N_X6_X1_33_X6_X1_X1_X1_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_M19 N_X6_X1_X1_X1_11_X6_X1_X1_X1_M19_d N_X6_X1_33_X6_X1_X1_X1_M19_g
+ N_VDD_X6_X1_X1_X1_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_X20_M0 N_X6_X1_X1_X1_16_X6_X1_X1_X1_X20_M0_d
+ N_X6_X1_X1_X1_X20_7_X6_X1_X1_X1_X20_M0_g N_X6_X1_33_X6_X1_X1_X1_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_X20_M1 N_7_X6_X1_X1_X1_X20_M1_d N_X6_X1_25_X6_X1_X1_X1_X20_M1_g
+ N_X6_X1_X1_X1_16_X6_X1_X1_X1_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_X20_M2 N_X6_X1_X1_X1_X20_7_X6_X1_X1_X1_X20_M2_d
+ N_X6_X1_25_X6_X1_X1_X1_X20_M2_g N_GROUND_X6_X1_X1_X1_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX6_X1_X1_X1_X20_M3 N_X6_X1_X1_X1_16_X6_X1_X1_X1_X20_M3_d
+ N_X6_X1_25_X6_X1_X1_X1_X20_M3_g N_X6_X1_33_X6_X1_X1_X1_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X1_X1_X20_M4 N_7_X6_X1_X1_X1_X20_M4_d
+ N_X6_X1_X1_X1_X20_7_X6_X1_X1_X1_X20_M4_g N_X6_X1_X1_X1_16_X6_X1_X1_X1_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X1_X1_X20_M5 N_X6_X1_X1_X1_X20_7_X6_X1_X1_X1_X20_M5_d
+ N_X6_X1_25_X6_X1_X1_X1_X20_M5_g N_VDD_X6_X1_X1_X1_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX6_X1_X2_X0_M0 N_GROUND_X6_X1_X2_X0_M0_d N_X6_X1_X2_X0_11_X6_X1_X2_X0_M0_g
+ N_X6_X1_34_X6_X1_X2_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M1 N_X6_X1_X2_X0_7_X6_X1_X2_X0_M1_d
+ N_X6_X1_X2_X0_10_X6_X1_X2_X0_M1_g N_GROUND_X6_X1_X2_X0_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M2 X6_X1_X2_X0_8 N_X6_X1_X2_X0_15_X6_X1_X2_X0_M2_g
+ N_X6_X1_X2_X0_7_X6_X1_X2_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M3 N_GROUND_X6_X1_X2_X0_M3_d N_X6_X1_X2_X0_16_X6_X1_X2_X0_M3_g
+ X6_X1_X2_X0_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M4 X6_X1_X2_X0_9 N_X6_X1_X2_X0_14_X6_X1_X2_X0_M4_g
+ N_GROUND_X6_X1_X2_X0_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M5 N_X6_X1_X2_X0_10_X6_X1_X2_X0_M5_d
+ N_X6_X1_X2_X0_15_X6_X1_X2_X0_M5_g X6_X1_X2_X0_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M6 N_GROUND_X6_X1_X2_X0_M6_d N_X6_X1_X2_X0_7_X6_X1_X2_X0_M6_g
+ N_X6_X1_X2_X0_10_X6_X1_X2_X0_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M7 N_X6_X1_X2_X0_11_X6_X1_X2_X0_M7_d N_X6_X1_34_X6_X1_X2_X0_M7_g
+ N_GROUND_X6_X1_X2_X0_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M8 X6_X1_X2_X0_12 N_CLK_X6_X1_X2_X0_M8_g
+ N_X6_X1_X2_X0_11_X6_X1_X2_X0_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M9 N_GROUND_X6_X1_X2_X0_M9_d N_X6_X1_X2_X0_10_X6_X1_X2_X0_M9_g
+ X6_X1_X2_X0_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M10 X6_X1_X2_X0_13 N_X6_X1_X2_X0_7_X6_X1_X2_X0_M10_g
+ N_GROUND_X6_X1_X2_X0_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M11 N_X6_X1_34_X6_X1_X2_X0_M11_d N_CLK_X6_X1_X2_X0_M11_g
+ X6_X1_X2_X0_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M12 N_GROUND_X6_X1_X2_X0_M12_d N_X6_X1_X2_X0_16_X6_X1_X2_X0_M12_g
+ N_X6_X1_X2_X0_14_X6_X1_X2_X0_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M13 N_X6_X1_X2_X0_15_X6_X1_X2_X0_M13_d N_CLK_X6_X1_X2_X0_M13_g
+ N_GROUND_X6_X1_X2_X0_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M14 N_VDD_X6_X1_X2_X0_M14_d N_X6_X1_X2_X0_16_X6_X1_X2_X0_M14_g
+ N_X6_X1_X2_X0_14_X6_X1_X2_X0_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M15 N_X6_X1_X2_X0_15_X6_X1_X2_X0_M15_d N_CLK_X6_X1_X2_X0_M15_g
+ N_VDD_X6_X1_X2_X0_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M16 N_VDD_X6_X1_X2_X0_M16_d N_X6_X1_X2_X0_7_X6_X1_X2_X0_M16_g
+ N_X6_X1_X2_X0_10_X6_X1_X2_X0_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M17 N_X6_X1_X2_X0_7_X6_X1_X2_X0_M17_d
+ N_X6_X1_X2_X0_10_X6_X1_X2_X0_M17_g N_VDD_X6_X1_X2_X0_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M18 N_VDD_X6_X1_X2_X0_M18_d N_X6_X1_X2_X0_11_X6_X1_X2_X0_M18_g
+ N_X6_X1_34_X6_X1_X2_X0_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_M19 N_X6_X1_X2_X0_11_X6_X1_X2_X0_M19_d N_X6_X1_34_X6_X1_X2_X0_M19_g
+ N_VDD_X6_X1_X2_X0_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_X20_M0 N_X6_X1_X2_X0_16_X6_X1_X2_X0_X20_M0_d
+ N_X6_X1_X2_X0_X20_7_X6_X1_X2_X0_X20_M0_g N_X6_X1_34_X6_X1_X2_X0_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_X20_M1 N_7_X6_X1_X2_X0_X20_M1_d N_X6_X1_26_X6_X1_X2_X0_X20_M1_g
+ N_X6_X1_X2_X0_16_X6_X1_X2_X0_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_X20_M2 N_X6_X1_X2_X0_X20_7_X6_X1_X2_X0_X20_M2_d
+ N_X6_X1_26_X6_X1_X2_X0_X20_M2_g N_GROUND_X6_X1_X2_X0_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X0_X20_M3 N_X6_X1_X2_X0_16_X6_X1_X2_X0_X20_M3_d
+ N_X6_X1_26_X6_X1_X2_X0_X20_M3_g N_X6_X1_34_X6_X1_X2_X0_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X2_X0_X20_M4 N_7_X6_X1_X2_X0_X20_M4_d
+ N_X6_X1_X2_X0_X20_7_X6_X1_X2_X0_X20_M4_g N_X6_X1_X2_X0_16_X6_X1_X2_X0_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X2_X0_X20_M5 N_X6_X1_X2_X0_X20_7_X6_X1_X2_X0_X20_M5_d
+ N_X6_X1_26_X6_X1_X2_X0_X20_M5_g N_VDD_X6_X1_X2_X0_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX6_X1_X2_X1_M0 N_GROUND_X6_X1_X2_X1_M0_d N_X6_X1_X2_X1_11_X6_X1_X2_X1_M0_g
+ N_X6_X1_35_X6_X1_X2_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M1 N_X6_X1_X2_X1_7_X6_X1_X2_X1_M1_d
+ N_X6_X1_X2_X1_10_X6_X1_X2_X1_M1_g N_GROUND_X6_X1_X2_X1_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M2 X6_X1_X2_X1_8 N_X6_X1_X2_X1_15_X6_X1_X2_X1_M2_g
+ N_X6_X1_X2_X1_7_X6_X1_X2_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M3 N_GROUND_X6_X1_X2_X1_M3_d N_X6_X1_X2_X1_16_X6_X1_X2_X1_M3_g
+ X6_X1_X2_X1_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M4 X6_X1_X2_X1_9 N_X6_X1_X2_X1_14_X6_X1_X2_X1_M4_g
+ N_GROUND_X6_X1_X2_X1_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M5 N_X6_X1_X2_X1_10_X6_X1_X2_X1_M5_d
+ N_X6_X1_X2_X1_15_X6_X1_X2_X1_M5_g X6_X1_X2_X1_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M6 N_GROUND_X6_X1_X2_X1_M6_d N_X6_X1_X2_X1_7_X6_X1_X2_X1_M6_g
+ N_X6_X1_X2_X1_10_X6_X1_X2_X1_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M7 N_X6_X1_X2_X1_11_X6_X1_X2_X1_M7_d N_X6_X1_35_X6_X1_X2_X1_M7_g
+ N_GROUND_X6_X1_X2_X1_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M8 X6_X1_X2_X1_12 N_CLK_X6_X1_X2_X1_M8_g
+ N_X6_X1_X2_X1_11_X6_X1_X2_X1_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M9 N_GROUND_X6_X1_X2_X1_M9_d N_X6_X1_X2_X1_10_X6_X1_X2_X1_M9_g
+ X6_X1_X2_X1_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M10 X6_X1_X2_X1_13 N_X6_X1_X2_X1_7_X6_X1_X2_X1_M10_g
+ N_GROUND_X6_X1_X2_X1_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M11 N_X6_X1_35_X6_X1_X2_X1_M11_d N_CLK_X6_X1_X2_X1_M11_g
+ X6_X1_X2_X1_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M12 N_GROUND_X6_X1_X2_X1_M12_d N_X6_X1_X2_X1_16_X6_X1_X2_X1_M12_g
+ N_X6_X1_X2_X1_14_X6_X1_X2_X1_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M13 N_X6_X1_X2_X1_15_X6_X1_X2_X1_M13_d N_CLK_X6_X1_X2_X1_M13_g
+ N_GROUND_X6_X1_X2_X1_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M14 N_VDD_X6_X1_X2_X1_M14_d N_X6_X1_X2_X1_16_X6_X1_X2_X1_M14_g
+ N_X6_X1_X2_X1_14_X6_X1_X2_X1_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M15 N_X6_X1_X2_X1_15_X6_X1_X2_X1_M15_d N_CLK_X6_X1_X2_X1_M15_g
+ N_VDD_X6_X1_X2_X1_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M16 N_VDD_X6_X1_X2_X1_M16_d N_X6_X1_X2_X1_7_X6_X1_X2_X1_M16_g
+ N_X6_X1_X2_X1_10_X6_X1_X2_X1_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M17 N_X6_X1_X2_X1_7_X6_X1_X2_X1_M17_d
+ N_X6_X1_X2_X1_10_X6_X1_X2_X1_M17_g N_VDD_X6_X1_X2_X1_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M18 N_VDD_X6_X1_X2_X1_M18_d N_X6_X1_X2_X1_11_X6_X1_X2_X1_M18_g
+ N_X6_X1_35_X6_X1_X2_X1_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_M19 N_X6_X1_X2_X1_11_X6_X1_X2_X1_M19_d N_X6_X1_35_X6_X1_X2_X1_M19_g
+ N_VDD_X6_X1_X2_X1_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_X20_M0 N_X6_X1_X2_X1_16_X6_X1_X2_X1_X20_M0_d
+ N_X6_X1_X2_X1_X20_7_X6_X1_X2_X1_X20_M0_g N_X6_X1_35_X6_X1_X2_X1_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_X20_M1 N_7_X6_X1_X2_X1_X20_M1_d N_X6_X1_27_X6_X1_X2_X1_X20_M1_g
+ N_X6_X1_X2_X1_16_X6_X1_X2_X1_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_X20_M2 N_X6_X1_X2_X1_X20_7_X6_X1_X2_X1_X20_M2_d
+ N_X6_X1_27_X6_X1_X2_X1_X20_M2_g N_GROUND_X6_X1_X2_X1_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX6_X1_X2_X1_X20_M3 N_X6_X1_X2_X1_16_X6_X1_X2_X1_X20_M3_d
+ N_X6_X1_27_X6_X1_X2_X1_X20_M3_g N_X6_X1_35_X6_X1_X2_X1_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X2_X1_X20_M4 N_7_X6_X1_X2_X1_X20_M4_d
+ N_X6_X1_X2_X1_X20_7_X6_X1_X2_X1_X20_M4_g N_X6_X1_X2_X1_16_X6_X1_X2_X1_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X2_X1_X20_M5 N_X6_X1_X2_X1_X20_7_X6_X1_X2_X1_X20_M5_d
+ N_X6_X1_27_X6_X1_X2_X1_X20_M5_g N_VDD_X6_X1_X2_X1_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX6_X1_X3_X0_M0 N_GROUND_X6_X1_X3_X0_M0_d N_X6_X1_X3_X0_11_X6_X1_X3_X0_M0_g
+ N_X6_X1_36_X6_X1_X3_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M1 N_X6_X1_X3_X0_7_X6_X1_X3_X0_M1_d
+ N_X6_X1_X3_X0_10_X6_X1_X3_X0_M1_g N_GROUND_X6_X1_X3_X0_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M2 X6_X1_X3_X0_8 N_X6_X1_X3_X0_15_X6_X1_X3_X0_M2_g
+ N_X6_X1_X3_X0_7_X6_X1_X3_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M3 N_GROUND_X6_X1_X3_X0_M3_d N_X6_X1_X3_X0_16_X6_X1_X3_X0_M3_g
+ X6_X1_X3_X0_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M4 X6_X1_X3_X0_9 N_X6_X1_X3_X0_14_X6_X1_X3_X0_M4_g
+ N_GROUND_X6_X1_X3_X0_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M5 N_X6_X1_X3_X0_10_X6_X1_X3_X0_M5_d
+ N_X6_X1_X3_X0_15_X6_X1_X3_X0_M5_g X6_X1_X3_X0_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M6 N_GROUND_X6_X1_X3_X0_M6_d N_X6_X1_X3_X0_7_X6_X1_X3_X0_M6_g
+ N_X6_X1_X3_X0_10_X6_X1_X3_X0_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M7 N_X6_X1_X3_X0_11_X6_X1_X3_X0_M7_d N_X6_X1_36_X6_X1_X3_X0_M7_g
+ N_GROUND_X6_X1_X3_X0_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M8 X6_X1_X3_X0_12 N_CLK_X6_X1_X3_X0_M8_g
+ N_X6_X1_X3_X0_11_X6_X1_X3_X0_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M9 N_GROUND_X6_X1_X3_X0_M9_d N_X6_X1_X3_X0_10_X6_X1_X3_X0_M9_g
+ X6_X1_X3_X0_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M10 X6_X1_X3_X0_13 N_X6_X1_X3_X0_7_X6_X1_X3_X0_M10_g
+ N_GROUND_X6_X1_X3_X0_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M11 N_X6_X1_36_X6_X1_X3_X0_M11_d N_CLK_X6_X1_X3_X0_M11_g
+ X6_X1_X3_X0_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M12 N_GROUND_X6_X1_X3_X0_M12_d N_X6_X1_X3_X0_16_X6_X1_X3_X0_M12_g
+ N_X6_X1_X3_X0_14_X6_X1_X3_X0_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M13 N_X6_X1_X3_X0_15_X6_X1_X3_X0_M13_d N_CLK_X6_X1_X3_X0_M13_g
+ N_GROUND_X6_X1_X3_X0_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M14 N_VDD_X6_X1_X3_X0_M14_d N_X6_X1_X3_X0_16_X6_X1_X3_X0_M14_g
+ N_X6_X1_X3_X0_14_X6_X1_X3_X0_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M15 N_X6_X1_X3_X0_15_X6_X1_X3_X0_M15_d N_CLK_X6_X1_X3_X0_M15_g
+ N_VDD_X6_X1_X3_X0_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M16 N_VDD_X6_X1_X3_X0_M16_d N_X6_X1_X3_X0_7_X6_X1_X3_X0_M16_g
+ N_X6_X1_X3_X0_10_X6_X1_X3_X0_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M17 N_X6_X1_X3_X0_7_X6_X1_X3_X0_M17_d
+ N_X6_X1_X3_X0_10_X6_X1_X3_X0_M17_g N_VDD_X6_X1_X3_X0_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M18 N_VDD_X6_X1_X3_X0_M18_d N_X6_X1_X3_X0_11_X6_X1_X3_X0_M18_g
+ N_X6_X1_36_X6_X1_X3_X0_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_M19 N_X6_X1_X3_X0_11_X6_X1_X3_X0_M19_d N_X6_X1_36_X6_X1_X3_X0_M19_g
+ N_VDD_X6_X1_X3_X0_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_X20_M0 N_X6_X1_X3_X0_16_X6_X1_X3_X0_X20_M0_d
+ N_X6_X1_X3_X0_X20_7_X6_X1_X3_X0_X20_M0_g N_X6_X1_36_X6_X1_X3_X0_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_X20_M1 N_7_X6_X1_X3_X0_X20_M1_d N_X6_X1_28_X6_X1_X3_X0_X20_M1_g
+ N_X6_X1_X3_X0_16_X6_X1_X3_X0_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_X20_M2 N_X6_X1_X3_X0_X20_7_X6_X1_X3_X0_X20_M2_d
+ N_X6_X1_28_X6_X1_X3_X0_X20_M2_g N_GROUND_X6_X1_X3_X0_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X0_X20_M3 N_X6_X1_X3_X0_16_X6_X1_X3_X0_X20_M3_d
+ N_X6_X1_28_X6_X1_X3_X0_X20_M3_g N_X6_X1_36_X6_X1_X3_X0_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X3_X0_X20_M4 N_7_X6_X1_X3_X0_X20_M4_d
+ N_X6_X1_X3_X0_X20_7_X6_X1_X3_X0_X20_M4_g N_X6_X1_X3_X0_16_X6_X1_X3_X0_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X3_X0_X20_M5 N_X6_X1_X3_X0_X20_7_X6_X1_X3_X0_X20_M5_d
+ N_X6_X1_28_X6_X1_X3_X0_X20_M5_g N_VDD_X6_X1_X3_X0_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX6_X1_X3_X1_M0 N_GROUND_X6_X1_X3_X1_M0_d N_X6_X1_X3_X1_11_X6_X1_X3_X1_M0_g
+ N_X6_X1_37_X6_X1_X3_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M1 N_X6_X1_X3_X1_7_X6_X1_X3_X1_M1_d
+ N_X6_X1_X3_X1_10_X6_X1_X3_X1_M1_g N_GROUND_X6_X1_X3_X1_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M2 X6_X1_X3_X1_8 N_X6_X1_X3_X1_15_X6_X1_X3_X1_M2_g
+ N_X6_X1_X3_X1_7_X6_X1_X3_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M3 N_GROUND_X6_X1_X3_X1_M3_d N_X6_X1_X3_X1_16_X6_X1_X3_X1_M3_g
+ X6_X1_X3_X1_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M4 X6_X1_X3_X1_9 N_X6_X1_X3_X1_14_X6_X1_X3_X1_M4_g
+ N_GROUND_X6_X1_X3_X1_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M5 N_X6_X1_X3_X1_10_X6_X1_X3_X1_M5_d
+ N_X6_X1_X3_X1_15_X6_X1_X3_X1_M5_g X6_X1_X3_X1_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M6 N_GROUND_X6_X1_X3_X1_M6_d N_X6_X1_X3_X1_7_X6_X1_X3_X1_M6_g
+ N_X6_X1_X3_X1_10_X6_X1_X3_X1_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M7 N_X6_X1_X3_X1_11_X6_X1_X3_X1_M7_d N_X6_X1_37_X6_X1_X3_X1_M7_g
+ N_GROUND_X6_X1_X3_X1_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M8 X6_X1_X3_X1_12 N_CLK_X6_X1_X3_X1_M8_g
+ N_X6_X1_X3_X1_11_X6_X1_X3_X1_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M9 N_GROUND_X6_X1_X3_X1_M9_d N_X6_X1_X3_X1_10_X6_X1_X3_X1_M9_g
+ X6_X1_X3_X1_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M10 X6_X1_X3_X1_13 N_X6_X1_X3_X1_7_X6_X1_X3_X1_M10_g
+ N_GROUND_X6_X1_X3_X1_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M11 N_X6_X1_37_X6_X1_X3_X1_M11_d N_CLK_X6_X1_X3_X1_M11_g
+ X6_X1_X3_X1_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M12 N_GROUND_X6_X1_X3_X1_M12_d N_X6_X1_X3_X1_16_X6_X1_X3_X1_M12_g
+ N_X6_X1_X3_X1_14_X6_X1_X3_X1_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M13 N_X6_X1_X3_X1_15_X6_X1_X3_X1_M13_d N_CLK_X6_X1_X3_X1_M13_g
+ N_GROUND_X6_X1_X3_X1_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M14 N_VDD_X6_X1_X3_X1_M14_d N_X6_X1_X3_X1_16_X6_X1_X3_X1_M14_g
+ N_X6_X1_X3_X1_14_X6_X1_X3_X1_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M15 N_X6_X1_X3_X1_15_X6_X1_X3_X1_M15_d N_CLK_X6_X1_X3_X1_M15_g
+ N_VDD_X6_X1_X3_X1_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M16 N_VDD_X6_X1_X3_X1_M16_d N_X6_X1_X3_X1_7_X6_X1_X3_X1_M16_g
+ N_X6_X1_X3_X1_10_X6_X1_X3_X1_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M17 N_X6_X1_X3_X1_7_X6_X1_X3_X1_M17_d
+ N_X6_X1_X3_X1_10_X6_X1_X3_X1_M17_g N_VDD_X6_X1_X3_X1_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M18 N_VDD_X6_X1_X3_X1_M18_d N_X6_X1_X3_X1_11_X6_X1_X3_X1_M18_g
+ N_X6_X1_37_X6_X1_X3_X1_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_M19 N_X6_X1_X3_X1_11_X6_X1_X3_X1_M19_d N_X6_X1_37_X6_X1_X3_X1_M19_g
+ N_VDD_X6_X1_X3_X1_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_X20_M0 N_X6_X1_X3_X1_16_X6_X1_X3_X1_X20_M0_d
+ N_X6_X1_X3_X1_X20_7_X6_X1_X3_X1_X20_M0_g N_X6_X1_37_X6_X1_X3_X1_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_X20_M1 N_7_X6_X1_X3_X1_X20_M1_d N_X6_X1_29_X6_X1_X3_X1_X20_M1_g
+ N_X6_X1_X3_X1_16_X6_X1_X3_X1_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_X20_M2 N_X6_X1_X3_X1_X20_7_X6_X1_X3_X1_X20_M2_d
+ N_X6_X1_29_X6_X1_X3_X1_X20_M2_g N_GROUND_X6_X1_X3_X1_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX6_X1_X3_X1_X20_M3 N_X6_X1_X3_X1_16_X6_X1_X3_X1_X20_M3_d
+ N_X6_X1_29_X6_X1_X3_X1_X20_M3_g N_X6_X1_37_X6_X1_X3_X1_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X3_X1_X20_M4 N_7_X6_X1_X3_X1_X20_M4_d
+ N_X6_X1_X3_X1_X20_7_X6_X1_X3_X1_X20_M4_g N_X6_X1_X3_X1_16_X6_X1_X3_X1_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X3_X1_X20_M5 N_X6_X1_X3_X1_X20_7_X6_X1_X3_X1_X20_M5_d
+ N_X6_X1_29_X6_X1_X3_X1_X20_M5_g N_VDD_X6_X1_X3_X1_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX6_X1_X4_X0_M0 X6_X1_X4_X0_7 N_19_X6_X1_X4_X0_M0_g
+ N_X6_X1_X4_X0_6_X6_X1_X4_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX6_X1_X4_X0_M1 N_GROUND_X6_X1_X4_X0_M1_d N_34_X6_X1_X4_X0_M1_g X6_X1_X4_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX6_X1_X4_X0_M2 N_X6_X1_22_X6_X1_X4_X0_M2_d N_X6_X1_X4_X0_6_X6_X1_X4_X0_M2_g
+ N_GROUND_X6_X1_X4_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X4_X0_M3 N_X6_X1_X4_X0_6_X6_X1_X4_X0_M3_d N_19_X6_X1_X4_X0_M3_g
+ N_VDD_X6_X1_X4_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X4_X0_M4 N_VDD_X6_X1_X4_X0_M4_d N_34_X6_X1_X4_X0_M4_g
+ N_X6_X1_X4_X0_6_X6_X1_X4_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X4_X0_M5 N_X6_X1_22_X6_X1_X4_X0_M5_d N_X6_X1_X4_X0_6_X6_X1_X4_X0_M5_g
+ N_VDD_X6_X1_X4_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X4_X1_M0 X6_X1_X4_X1_7 N_20_X6_X1_X4_X1_M0_g
+ N_X6_X1_X4_X1_6_X6_X1_X4_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX6_X1_X4_X1_M1 N_GROUND_X6_X1_X4_X1_M1_d N_34_X6_X1_X4_X1_M1_g X6_X1_X4_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX6_X1_X4_X1_M2 N_X6_X1_23_X6_X1_X4_X1_M2_d N_X6_X1_X4_X1_6_X6_X1_X4_X1_M2_g
+ N_GROUND_X6_X1_X4_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X4_X1_M3 N_X6_X1_X4_X1_6_X6_X1_X4_X1_M3_d N_20_X6_X1_X4_X1_M3_g
+ N_VDD_X6_X1_X4_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X4_X1_M4 N_VDD_X6_X1_X4_X1_M4_d N_34_X6_X1_X4_X1_M4_g
+ N_X6_X1_X4_X1_6_X6_X1_X4_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X4_X1_M5 N_X6_X1_23_X6_X1_X4_X1_M5_d N_X6_X1_X4_X1_6_X6_X1_X4_X1_M5_g
+ N_VDD_X6_X1_X4_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X5_X0_M0 X6_X1_X5_X0_7 N_21_X6_X1_X5_X0_M0_g
+ N_X6_X1_X5_X0_6_X6_X1_X5_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX6_X1_X5_X0_M1 N_GROUND_X6_X1_X5_X0_M1_d N_34_X6_X1_X5_X0_M1_g X6_X1_X5_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX6_X1_X5_X0_M2 N_X6_X1_24_X6_X1_X5_X0_M2_d N_X6_X1_X5_X0_6_X6_X1_X5_X0_M2_g
+ N_GROUND_X6_X1_X5_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X5_X0_M3 N_X6_X1_X5_X0_6_X6_X1_X5_X0_M3_d N_21_X6_X1_X5_X0_M3_g
+ N_VDD_X6_X1_X5_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X5_X0_M4 N_VDD_X6_X1_X5_X0_M4_d N_34_X6_X1_X5_X0_M4_g
+ N_X6_X1_X5_X0_6_X6_X1_X5_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X5_X0_M5 N_X6_X1_24_X6_X1_X5_X0_M5_d N_X6_X1_X5_X0_6_X6_X1_X5_X0_M5_g
+ N_VDD_X6_X1_X5_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X5_X1_M0 X6_X1_X5_X1_7 N_22_X6_X1_X5_X1_M0_g
+ N_X6_X1_X5_X1_6_X6_X1_X5_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX6_X1_X5_X1_M1 N_GROUND_X6_X1_X5_X1_M1_d N_34_X6_X1_X5_X1_M1_g X6_X1_X5_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX6_X1_X5_X1_M2 N_X6_X1_25_X6_X1_X5_X1_M2_d N_X6_X1_X5_X1_6_X6_X1_X5_X1_M2_g
+ N_GROUND_X6_X1_X5_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X5_X1_M3 N_X6_X1_X5_X1_6_X6_X1_X5_X1_M3_d N_22_X6_X1_X5_X1_M3_g
+ N_VDD_X6_X1_X5_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X5_X1_M4 N_VDD_X6_X1_X5_X1_M4_d N_34_X6_X1_X5_X1_M4_g
+ N_X6_X1_X5_X1_6_X6_X1_X5_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X5_X1_M5 N_X6_X1_25_X6_X1_X5_X1_M5_d N_X6_X1_X5_X1_6_X6_X1_X5_X1_M5_g
+ N_VDD_X6_X1_X5_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X6_X0_M0 X6_X1_X6_X0_7 N_23_X6_X1_X6_X0_M0_g
+ N_X6_X1_X6_X0_6_X6_X1_X6_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX6_X1_X6_X0_M1 N_GROUND_X6_X1_X6_X0_M1_d N_34_X6_X1_X6_X0_M1_g X6_X1_X6_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX6_X1_X6_X0_M2 N_X6_X1_26_X6_X1_X6_X0_M2_d N_X6_X1_X6_X0_6_X6_X1_X6_X0_M2_g
+ N_GROUND_X6_X1_X6_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X6_X0_M3 N_X6_X1_X6_X0_6_X6_X1_X6_X0_M3_d N_23_X6_X1_X6_X0_M3_g
+ N_VDD_X6_X1_X6_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X6_X0_M4 N_VDD_X6_X1_X6_X0_M4_d N_34_X6_X1_X6_X0_M4_g
+ N_X6_X1_X6_X0_6_X6_X1_X6_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X6_X0_M5 N_X6_X1_26_X6_X1_X6_X0_M5_d N_X6_X1_X6_X0_6_X6_X1_X6_X0_M5_g
+ N_VDD_X6_X1_X6_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X6_X1_M0 X6_X1_X6_X1_7 N_24_X6_X1_X6_X1_M0_g
+ N_X6_X1_X6_X1_6_X6_X1_X6_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX6_X1_X6_X1_M1 N_GROUND_X6_X1_X6_X1_M1_d N_34_X6_X1_X6_X1_M1_g X6_X1_X6_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX6_X1_X6_X1_M2 N_X6_X1_27_X6_X1_X6_X1_M2_d N_X6_X1_X6_X1_6_X6_X1_X6_X1_M2_g
+ N_GROUND_X6_X1_X6_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X6_X1_M3 N_X6_X1_X6_X1_6_X6_X1_X6_X1_M3_d N_24_X6_X1_X6_X1_M3_g
+ N_VDD_X6_X1_X6_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X6_X1_M4 N_VDD_X6_X1_X6_X1_M4_d N_34_X6_X1_X6_X1_M4_g
+ N_X6_X1_X6_X1_6_X6_X1_X6_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X6_X1_M5 N_X6_X1_27_X6_X1_X6_X1_M5_d N_X6_X1_X6_X1_6_X6_X1_X6_X1_M5_g
+ N_VDD_X6_X1_X6_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X7_X0_M0 X6_X1_X7_X0_7 N_25_X6_X1_X7_X0_M0_g
+ N_X6_X1_X7_X0_6_X6_X1_X7_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX6_X1_X7_X0_M1 N_GROUND_X6_X1_X7_X0_M1_d N_34_X6_X1_X7_X0_M1_g X6_X1_X7_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX6_X1_X7_X0_M2 N_X6_X1_28_X6_X1_X7_X0_M2_d N_X6_X1_X7_X0_6_X6_X1_X7_X0_M2_g
+ N_GROUND_X6_X1_X7_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X7_X0_M3 N_X6_X1_X7_X0_6_X6_X1_X7_X0_M3_d N_25_X6_X1_X7_X0_M3_g
+ N_VDD_X6_X1_X7_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X7_X0_M4 N_VDD_X6_X1_X7_X0_M4_d N_34_X6_X1_X7_X0_M4_g
+ N_X6_X1_X7_X0_6_X6_X1_X7_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X7_X0_M5 N_X6_X1_28_X6_X1_X7_X0_M5_d N_X6_X1_X7_X0_6_X6_X1_X7_X0_M5_g
+ N_VDD_X6_X1_X7_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X7_X1_M0 X6_X1_X7_X1_7 N_26_X6_X1_X7_X1_M0_g
+ N_X6_X1_X7_X1_6_X6_X1_X7_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX6_X1_X7_X1_M1 N_GROUND_X6_X1_X7_X1_M1_d N_34_X6_X1_X7_X1_M1_g X6_X1_X7_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX6_X1_X7_X1_M2 N_X6_X1_29_X6_X1_X7_X1_M2_d N_X6_X1_X7_X1_6_X6_X1_X7_X1_M2_g
+ N_GROUND_X6_X1_X7_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X7_X1_M3 N_X6_X1_X7_X1_6_X6_X1_X7_X1_M3_d N_26_X6_X1_X7_X1_M3_g
+ N_VDD_X6_X1_X7_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X7_X1_M4 N_VDD_X6_X1_X7_X1_M4_d N_34_X6_X1_X7_X1_M4_g
+ N_X6_X1_X7_X1_6_X6_X1_X7_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X7_X1_M5 N_X6_X1_29_X6_X1_X7_X1_M5_d N_X6_X1_X7_X1_6_X6_X1_X7_X1_M5_g
+ N_VDD_X6_X1_X7_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X0_M0 N_X6_X1_X8_15_X6_X1_X8_X0_M0_d N_X6_X1_X8_X0_7_X6_X1_X8_X0_M0_g
+ N_X6_X1_30_X6_X1_X8_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X0_M1 N_X6_X1_31_X6_X1_X8_X0_M1_d N_RS0_X6_X1_X8_X0_M1_g
+ N_X6_X1_X8_15_X6_X1_X8_X0_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X0_M2 N_X6_X1_X8_X0_7_X6_X1_X8_X0_M2_d N_RS0_X6_X1_X8_X0_M2_g
+ N_GROUND_X6_X1_X8_X0_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X0_M3 N_X6_X1_X8_15_X6_X1_X8_X0_M3_d N_RS0_X6_X1_X8_X0_M3_g
+ N_X6_X1_30_X6_X1_X8_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X0_M4 N_X6_X1_31_X6_X1_X8_X0_M4_d N_X6_X1_X8_X0_7_X6_X1_X8_X0_M4_g
+ N_X6_X1_X8_15_X6_X1_X8_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X0_M5 N_X6_X1_X8_X0_7_X6_X1_X8_X0_M5_d N_RS0_X6_X1_X8_X0_M5_g
+ N_VDD_X6_X1_X8_X0_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X1_M0 N_X6_X1_X8_16_X6_X1_X8_X1_M0_d N_X6_X1_X8_X1_7_X6_X1_X8_X1_M0_g
+ N_X6_X1_32_X6_X1_X8_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X1_M1 N_X6_X1_33_X6_X1_X8_X1_M1_d N_RS0_X6_X1_X8_X1_M1_g
+ N_X6_X1_X8_16_X6_X1_X8_X1_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X1_M2 N_X6_X1_X8_X1_7_X6_X1_X8_X1_M2_d N_RS0_X6_X1_X8_X1_M2_g
+ N_GROUND_X6_X1_X8_X1_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X1_M3 N_X6_X1_X8_16_X6_X1_X8_X1_M3_d N_RS0_X6_X1_X8_X1_M3_g
+ N_X6_X1_32_X6_X1_X8_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X1_M4 N_X6_X1_33_X6_X1_X8_X1_M4_d N_X6_X1_X8_X1_7_X6_X1_X8_X1_M4_g
+ N_X6_X1_X8_16_X6_X1_X8_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X1_M5 N_X6_X1_X8_X1_7_X6_X1_X8_X1_M5_d N_RS0_X6_X1_X8_X1_M5_g
+ N_VDD_X6_X1_X8_X1_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X2_M0 N_X6_X1_X8_19_X6_X1_X8_X2_M0_d N_X6_X1_X8_X2_7_X6_X1_X8_X2_M0_g
+ N_X6_X1_X8_15_X6_X1_X8_X2_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X2_M1 N_X6_X1_X8_16_X6_X1_X8_X2_M1_d N_RS1_X6_X1_X8_X2_M1_g
+ N_X6_X1_X8_19_X6_X1_X8_X2_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X2_M2 N_X6_X1_X8_X2_7_X6_X1_X8_X2_M2_d N_RS1_X6_X1_X8_X2_M2_g
+ N_GROUND_X6_X1_X8_X2_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X2_M3 N_X6_X1_X8_19_X6_X1_X8_X2_M3_d N_RS1_X6_X1_X8_X2_M3_g
+ N_X6_X1_X8_15_X6_X1_X8_X2_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X2_M4 N_X6_X1_X8_16_X6_X1_X8_X2_M4_d N_X6_X1_X8_X2_7_X6_X1_X8_X2_M4_g
+ N_X6_X1_X8_19_X6_X1_X8_X2_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X2_M5 N_X6_X1_X8_X2_7_X6_X1_X8_X2_M5_d N_RS1_X6_X1_X8_X2_M5_g
+ N_VDD_X6_X1_X8_X2_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X3_M0 N_X6_X1_X8_17_X6_X1_X8_X3_M0_d N_X6_X1_X8_X3_7_X6_X1_X8_X3_M0_g
+ N_X6_X1_34_X6_X1_X8_X3_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X3_M1 N_X6_X1_35_X6_X1_X8_X3_M1_d N_RS0_X6_X1_X8_X3_M1_g
+ N_X6_X1_X8_17_X6_X1_X8_X3_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X3_M2 N_X6_X1_X8_X3_7_X6_X1_X8_X3_M2_d N_RS0_X6_X1_X8_X3_M2_g
+ N_GROUND_X6_X1_X8_X3_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X3_M3 N_X6_X1_X8_17_X6_X1_X8_X3_M3_d N_RS0_X6_X1_X8_X3_M3_g
+ N_X6_X1_34_X6_X1_X8_X3_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X3_M4 N_X6_X1_35_X6_X1_X8_X3_M4_d N_X6_X1_X8_X3_7_X6_X1_X8_X3_M4_g
+ N_X6_X1_X8_17_X6_X1_X8_X3_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X3_M5 N_X6_X1_X8_X3_7_X6_X1_X8_X3_M5_d N_RS0_X6_X1_X8_X3_M5_g
+ N_VDD_X6_X1_X8_X3_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X4_M0 N_X6_X1_X8_18_X6_X1_X8_X4_M0_d N_X6_X1_X8_X4_7_X6_X1_X8_X4_M0_g
+ N_X6_X1_36_X6_X1_X8_X4_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X4_M1 N_X6_X1_37_X6_X1_X8_X4_M1_d N_RS0_X6_X1_X8_X4_M1_g
+ N_X6_X1_X8_18_X6_X1_X8_X4_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X4_M2 N_X6_X1_X8_X4_7_X6_X1_X8_X4_M2_d N_RS0_X6_X1_X8_X4_M2_g
+ N_GROUND_X6_X1_X8_X4_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X4_M3 N_X6_X1_X8_18_X6_X1_X8_X4_M3_d N_RS0_X6_X1_X8_X4_M3_g
+ N_X6_X1_36_X6_X1_X8_X4_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X4_M4 N_X6_X1_37_X6_X1_X8_X4_M4_d N_X6_X1_X8_X4_7_X6_X1_X8_X4_M4_g
+ N_X6_X1_X8_18_X6_X1_X8_X4_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X4_M5 N_X6_X1_X8_X4_7_X6_X1_X8_X4_M5_d N_RS0_X6_X1_X8_X4_M5_g
+ N_VDD_X6_X1_X8_X4_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X5_M0 N_X6_X1_X8_20_X6_X1_X8_X5_M0_d N_X6_X1_X8_X5_7_X6_X1_X8_X5_M0_g
+ N_X6_X1_X8_17_X6_X1_X8_X5_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X5_M1 N_X6_X1_X8_18_X6_X1_X8_X5_M1_d N_RS1_X6_X1_X8_X5_M1_g
+ N_X6_X1_X8_20_X6_X1_X8_X5_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X5_M2 N_X6_X1_X8_X5_7_X6_X1_X8_X5_M2_d N_RS1_X6_X1_X8_X5_M2_g
+ N_GROUND_X6_X1_X8_X5_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X5_M3 N_X6_X1_X8_20_X6_X1_X8_X5_M3_d N_RS1_X6_X1_X8_X5_M3_g
+ N_X6_X1_X8_17_X6_X1_X8_X5_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X5_M4 N_X6_X1_X8_18_X6_X1_X8_X5_M4_d N_X6_X1_X8_X5_7_X6_X1_X8_X5_M4_g
+ N_X6_X1_X8_20_X6_X1_X8_X5_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X5_M5 N_X6_X1_X8_X5_7_X6_X1_X8_X5_M5_d N_RS1_X6_X1_X8_X5_M5_g
+ N_VDD_X6_X1_X8_X5_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X6_M0 N_X6_47_X6_X1_X8_X6_M0_d N_X6_X1_X8_X6_7_X6_X1_X8_X6_M0_g
+ N_X6_X1_X8_19_X6_X1_X8_X6_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X6_M1 N_X6_X1_X8_20_X6_X1_X8_X6_M1_d N_RS2_X6_X1_X8_X6_M1_g
+ N_X6_47_X6_X1_X8_X6_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X6_M2 N_X6_X1_X8_X6_7_X6_X1_X8_X6_M2_d N_RS2_X6_X1_X8_X6_M2_g
+ N_GROUND_X6_X1_X8_X6_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X8_X6_M3 N_X6_47_X6_X1_X8_X6_M3_d N_RS2_X6_X1_X8_X6_M3_g
+ N_X6_X1_X8_19_X6_X1_X8_X6_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X6_M4 N_X6_X1_X8_20_X6_X1_X8_X6_M4_d N_X6_X1_X8_X6_7_X6_X1_X8_X6_M4_g
+ N_X6_47_X6_X1_X8_X6_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X8_X6_M5 N_X6_X1_X8_X6_7_X6_X1_X8_X6_M5_d N_RS2_X6_X1_X8_X6_M5_g
+ N_VDD_X6_X1_X8_X6_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X0_M0 N_X6_X1_X9_15_X6_X1_X9_X0_M0_d N_X6_X1_X9_X0_7_X6_X1_X9_X0_M0_g
+ N_X6_X1_30_X6_X1_X9_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X0_M1 N_X6_X1_31_X6_X1_X9_X0_M1_d N_RT0_X6_X1_X9_X0_M1_g
+ N_X6_X1_X9_15_X6_X1_X9_X0_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X0_M2 N_X6_X1_X9_X0_7_X6_X1_X9_X0_M2_d N_RT0_X6_X1_X9_X0_M2_g
+ N_GROUND_X6_X1_X9_X0_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X0_M3 N_X6_X1_X9_15_X6_X1_X9_X0_M3_d N_RT0_X6_X1_X9_X0_M3_g
+ N_X6_X1_30_X6_X1_X9_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X0_M4 N_X6_X1_31_X6_X1_X9_X0_M4_d N_X6_X1_X9_X0_7_X6_X1_X9_X0_M4_g
+ N_X6_X1_X9_15_X6_X1_X9_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X0_M5 N_X6_X1_X9_X0_7_X6_X1_X9_X0_M5_d N_RT0_X6_X1_X9_X0_M5_g
+ N_VDD_X6_X1_X9_X0_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X1_M0 N_X6_X1_X9_16_X6_X1_X9_X1_M0_d N_X6_X1_X9_X1_7_X6_X1_X9_X1_M0_g
+ N_X6_X1_32_X6_X1_X9_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X1_M1 N_X6_X1_33_X6_X1_X9_X1_M1_d N_RT0_X6_X1_X9_X1_M1_g
+ N_X6_X1_X9_16_X6_X1_X9_X1_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X1_M2 N_X6_X1_X9_X1_7_X6_X1_X9_X1_M2_d N_RT0_X6_X1_X9_X1_M2_g
+ N_GROUND_X6_X1_X9_X1_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X1_M3 N_X6_X1_X9_16_X6_X1_X9_X1_M3_d N_RT0_X6_X1_X9_X1_M3_g
+ N_X6_X1_32_X6_X1_X9_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X1_M4 N_X6_X1_33_X6_X1_X9_X1_M4_d N_X6_X1_X9_X1_7_X6_X1_X9_X1_M4_g
+ N_X6_X1_X9_16_X6_X1_X9_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X1_M5 N_X6_X1_X9_X1_7_X6_X1_X9_X1_M5_d N_RT0_X6_X1_X9_X1_M5_g
+ N_VDD_X6_X1_X9_X1_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X2_M0 N_X6_X1_X9_19_X6_X1_X9_X2_M0_d N_X6_X1_X9_X2_7_X6_X1_X9_X2_M0_g
+ N_X6_X1_X9_15_X6_X1_X9_X2_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X2_M1 N_X6_X1_X9_16_X6_X1_X9_X2_M1_d N_RT1_X6_X1_X9_X2_M1_g
+ N_X6_X1_X9_19_X6_X1_X9_X2_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X2_M2 N_X6_X1_X9_X2_7_X6_X1_X9_X2_M2_d N_RT1_X6_X1_X9_X2_M2_g
+ N_GROUND_X6_X1_X9_X2_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X2_M3 N_X6_X1_X9_19_X6_X1_X9_X2_M3_d N_RT1_X6_X1_X9_X2_M3_g
+ N_X6_X1_X9_15_X6_X1_X9_X2_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X2_M4 N_X6_X1_X9_16_X6_X1_X9_X2_M4_d N_X6_X1_X9_X2_7_X6_X1_X9_X2_M4_g
+ N_X6_X1_X9_19_X6_X1_X9_X2_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X2_M5 N_X6_X1_X9_X2_7_X6_X1_X9_X2_M5_d N_RT1_X6_X1_X9_X2_M5_g
+ N_VDD_X6_X1_X9_X2_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X3_M0 N_X6_X1_X9_17_X6_X1_X9_X3_M0_d N_X6_X1_X9_X3_7_X6_X1_X9_X3_M0_g
+ N_X6_X1_34_X6_X1_X9_X3_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X3_M1 N_X6_X1_35_X6_X1_X9_X3_M1_d N_RT0_X6_X1_X9_X3_M1_g
+ N_X6_X1_X9_17_X6_X1_X9_X3_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X3_M2 N_X6_X1_X9_X3_7_X6_X1_X9_X3_M2_d N_RT0_X6_X1_X9_X3_M2_g
+ N_GROUND_X6_X1_X9_X3_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X3_M3 N_X6_X1_X9_17_X6_X1_X9_X3_M3_d N_RT0_X6_X1_X9_X3_M3_g
+ N_X6_X1_34_X6_X1_X9_X3_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X3_M4 N_X6_X1_35_X6_X1_X9_X3_M4_d N_X6_X1_X9_X3_7_X6_X1_X9_X3_M4_g
+ N_X6_X1_X9_17_X6_X1_X9_X3_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X3_M5 N_X6_X1_X9_X3_7_X6_X1_X9_X3_M5_d N_RT0_X6_X1_X9_X3_M5_g
+ N_VDD_X6_X1_X9_X3_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X4_M0 N_X6_X1_X9_18_X6_X1_X9_X4_M0_d N_X6_X1_X9_X4_7_X6_X1_X9_X4_M0_g
+ N_X6_X1_36_X6_X1_X9_X4_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X4_M1 N_X6_X1_37_X6_X1_X9_X4_M1_d N_RT0_X6_X1_X9_X4_M1_g
+ N_X6_X1_X9_18_X6_X1_X9_X4_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X4_M2 N_X6_X1_X9_X4_7_X6_X1_X9_X4_M2_d N_RT0_X6_X1_X9_X4_M2_g
+ N_GROUND_X6_X1_X9_X4_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X4_M3 N_X6_X1_X9_18_X6_X1_X9_X4_M3_d N_RT0_X6_X1_X9_X4_M3_g
+ N_X6_X1_36_X6_X1_X9_X4_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X4_M4 N_X6_X1_37_X6_X1_X9_X4_M4_d N_X6_X1_X9_X4_7_X6_X1_X9_X4_M4_g
+ N_X6_X1_X9_18_X6_X1_X9_X4_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X4_M5 N_X6_X1_X9_X4_7_X6_X1_X9_X4_M5_d N_RT0_X6_X1_X9_X4_M5_g
+ N_VDD_X6_X1_X9_X4_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X5_M0 N_X6_X1_X9_20_X6_X1_X9_X5_M0_d N_X6_X1_X9_X5_7_X6_X1_X9_X5_M0_g
+ N_X6_X1_X9_17_X6_X1_X9_X5_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X5_M1 N_X6_X1_X9_18_X6_X1_X9_X5_M1_d N_RT1_X6_X1_X9_X5_M1_g
+ N_X6_X1_X9_20_X6_X1_X9_X5_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X5_M2 N_X6_X1_X9_X5_7_X6_X1_X9_X5_M2_d N_RT1_X6_X1_X9_X5_M2_g
+ N_GROUND_X6_X1_X9_X5_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X5_M3 N_X6_X1_X9_20_X6_X1_X9_X5_M3_d N_RT1_X6_X1_X9_X5_M3_g
+ N_X6_X1_X9_17_X6_X1_X9_X5_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X5_M4 N_X6_X1_X9_18_X6_X1_X9_X5_M4_d N_X6_X1_X9_X5_7_X6_X1_X9_X5_M4_g
+ N_X6_X1_X9_20_X6_X1_X9_X5_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X5_M5 N_X6_X1_X9_X5_7_X6_X1_X9_X5_M5_d N_RT1_X6_X1_X9_X5_M5_g
+ N_VDD_X6_X1_X9_X5_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X6_M0 N_X6_48_X6_X1_X9_X6_M0_d N_X6_X1_X9_X6_7_X6_X1_X9_X6_M0_g
+ N_X6_X1_X9_19_X6_X1_X9_X6_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X6_M1 N_X6_X1_X9_20_X6_X1_X9_X6_M1_d N_RT2_X6_X1_X9_X6_M1_g
+ N_X6_48_X6_X1_X9_X6_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X6_M2 N_X6_X1_X9_X6_7_X6_X1_X9_X6_M2_d N_RT2_X6_X1_X9_X6_M2_g
+ N_GROUND_X6_X1_X9_X6_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX6_X1_X9_X6_M3 N_X6_48_X6_X1_X9_X6_M3_d N_RT2_X6_X1_X9_X6_M3_g
+ N_X6_X1_X9_19_X6_X1_X9_X6_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X6_M4 N_X6_X1_X9_20_X6_X1_X9_X6_M4_d N_X6_X1_X9_X6_7_X6_X1_X9_X6_M4_g
+ N_X6_48_X6_X1_X9_X6_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX6_X1_X9_X6_M5 N_X6_X1_X9_X6_7_X6_X1_X9_X6_M5_d N_RT2_X6_X1_X9_X6_M5_g
+ N_VDD_X6_X1_X9_X6_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_M0 X7_X0_11 N_39_X7_X0_M0_g N_X7_X0_10_X7_X0_M0_s N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=2e-06
mX7_X0_M1 X7_X0_12 N_X7_X0_23_X7_X0_M1_g X7_X0_11 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=2e-06
mX7_X0_M2 N_GROUND_X7_X0_M2_d N_X7_47_X7_X0_M2_g X7_X0_12 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=2e-06
mX7_X0_M3 N_40_X7_X0_M3_d N_X7_X0_16_X7_X0_M3_g N_GROUND_X7_X0_M2_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX7_X0_M4 N_GROUND_X7_X0_M4_d N_X7_X0_10_X7_X0_M4_g N_X7_X0_13_X7_X0_M4_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX7_X0_M5 N_X7_X0_14_X7_X0_M5_d N_39_X7_X0_M5_g N_GROUND_X7_X0_M4_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX7_X0_M6 N_GROUND_X7_X0_M6_d N_X7_X0_23_X7_X0_M6_g N_X7_X0_14_X7_X0_M5_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX7_X0_M7 N_X7_X0_14_X7_X0_M7_d N_X7_47_X7_X0_M7_g N_GROUND_X7_X0_M6_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX7_X0_M8 N_X7_X0_10_X7_X0_M8_d N_X7_X0_16_X7_X0_M8_g N_X7_X0_14_X7_X0_M7_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX7_X0_M9 N_X7_X0_15_X7_X0_M9_d N_X7_X0_23_X7_X0_M9_g N_GROUND_X7_X0_M9_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX7_X0_M10 N_X7_X0_16_X7_X0_M10_d N_39_X7_X0_M10_g N_X7_X0_15_X7_X0_M9_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX7_X0_M11 X7_X0_17 N_X7_47_X7_X0_M11_g N_X7_X0_16_X7_X0_M10_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=2e-06
mX7_X0_M12 N_GROUND_X7_X0_M12_d N_X7_X0_23_X7_X0_M12_g X7_X0_17 N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=2e-06
mX7_X0_M13 N_X7_X0_15_X7_X0_M13_d N_X7_47_X7_X0_M13_g N_GROUND_X7_X0_M12_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=2e-06
mX7_X0_M14 N_X7_X0_16_X7_X0_M14_d N_39_X7_X0_M14_g N_X7_X0_18_X7_X0_M14_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX7_X0_M15 X7_X0_19 N_X7_47_X7_X0_M15_g N_X7_X0_16_X7_X0_M14_d N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=2e-06
mX7_X0_M16 N_VDD_X7_X0_M16_d N_X7_X0_23_X7_X0_M16_g X7_X0_19 N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=2e-06
mX7_X0_M17 N_X7_X0_18_X7_X0_M17_d N_X7_X0_23_X7_X0_M17_g N_VDD_X7_X0_M16_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX7_X0_M18 N_VDD_X7_X0_M18_d N_X7_47_X7_X0_M18_g N_X7_X0_18_X7_X0_M17_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX7_X0_M19 X7_X0_20 N_X7_47_X7_X0_M19_g N_VDD_X7_X0_M18_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=2e-06
mX7_X0_M20 X7_X0_21 N_X7_X0_23_X7_X0_M20_g X7_X0_20 N_VDD_X0_M3_b PMOS L=1.3e-07
+ W=2e-06
mX7_X0_M21 N_X7_X0_10_X7_X0_M21_d N_39_X7_X0_M21_g X7_X0_21 N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=2e-06
mX7_X0_M22 N_X7_X0_22_X7_X0_M22_d N_X7_X0_16_X7_X0_M22_g N_X7_X0_10_X7_X0_M21_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX7_X0_M23 N_VDD_X7_X0_M23_d N_X7_X0_16_X7_X0_M23_g N_40_X7_X0_M23_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX7_X0_M24 N_X7_X0_22_X7_X0_M24_d N_X7_47_X7_X0_M24_g N_VDD_X7_X0_M23_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX7_X0_M25 N_VDD_X7_X0_M25_d N_X7_X0_23_X7_X0_M25_g N_X7_X0_22_X7_X0_M24_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX7_X0_M26 N_X7_X0_22_X7_X0_M26_d N_39_X7_X0_M26_g N_VDD_X7_X0_M25_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX7_X0_M27 N_X7_X0_13_X7_X0_M27_d N_X7_X0_10_X7_X0_M27_g N_VDD_X7_X0_M27_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2e-06
mX7_X0_X28_M0 N_X7_X0_X28_6_X7_X0_X28_M0_d N_X7_48_X7_X0_X28_M0_g
+ N_GROUND_X7_X0_X28_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X0_X28_M1 N_GROUND_X7_X0_X28_M1_d N_X7_47_X7_X0_X28_M1_g
+ N_X7_X0_X28_6_X7_X0_X28_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X0_X28_M2 N_X7_X0_24_X7_X0_X28_M2_d N_X7_X0_X28_6_X7_X0_X28_M2_g
+ N_GROUND_X7_X0_X28_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X0_X28_M3 N_VDD_X7_X0_X28_M3_d N_X7_X0_X28_6_X7_X0_X28_M3_g
+ N_X7_X0_24_X7_X0_X28_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_X28_M4 X7_X0_X28_7 N_X7_47_X7_X0_X28_M4_g N_VDD_X7_X0_X28_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX7_X0_X28_M5 N_X7_X0_X28_6_X7_X0_X28_M5_d N_X7_48_X7_X0_X28_M5_g X7_X0_X28_7
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX7_X0_X29_M0 N_X7_X0_25_X7_X0_X29_M0_d N_X7_48_X7_X0_X29_M0_g
+ N_GROUND_X7_X0_X29_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X0_X29_M1 N_X7_X0_25_X7_X0_X29_M1_d N_X7_48_X7_X0_X29_M1_g
+ N_VDD_X7_X0_X29_M1_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_X30_M0 N_X7_X0_23_X7_X0_X30_M0_d N_X7_X0_X30_7_X7_X0_X30_M0_g
+ N_X7_48_X7_X0_X30_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X0_X30_M1 N_X7_X0_25_X7_X0_X30_M1_d N_29_X7_X0_X30_M1_g
+ N_X7_X0_23_X7_X0_X30_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X0_X30_M2 N_X7_X0_X30_7_X7_X0_X30_M2_d N_29_X7_X0_X30_M2_g
+ N_GROUND_X7_X0_X30_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X0_X30_M3 N_X7_X0_23_X7_X0_X30_M3_d N_29_X7_X0_X30_M3_g
+ N_X7_48_X7_X0_X30_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_X30_M4 N_X7_X0_25_X7_X0_X30_M4_d N_X7_X0_X30_7_X7_X0_X30_M4_g
+ N_X7_X0_23_X7_X0_X30_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_X30_M5 N_X7_X0_X30_7_X7_X0_X30_M5_d N_29_X7_X0_X30_M5_g
+ N_VDD_X7_X0_X30_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_X31_M0 N_X7_X0_27_X7_X0_X31_M0_d N_X7_X0_X31_7_X7_X0_X31_M0_g
+ N_X7_X0_13_X7_X0_X31_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X0_X31_M1 N_X7_X0_13_X7_X0_X31_M1_d N_29_X7_X0_X31_M1_g
+ N_X7_X0_27_X7_X0_X31_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X0_X31_M2 N_X7_X0_X31_7_X7_X0_X31_M2_d N_29_X7_X0_X31_M2_g
+ N_GROUND_X7_X0_X31_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X0_X31_M3 N_X7_X0_27_X7_X0_X31_M3_d N_29_X7_X0_X31_M3_g
+ N_X7_X0_13_X7_X0_X31_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_X31_M4 N_X7_X0_13_X7_X0_X31_M4_d N_X7_X0_X31_7_X7_X0_X31_M4_g
+ N_X7_X0_27_X7_X0_X31_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_X31_M5 N_X7_X0_X31_7_X7_X0_X31_M5_d N_29_X7_X0_X31_M5_g
+ N_VDD_X7_X0_X31_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_X32_M0 N_RESULT1_X7_X0_X32_M0_d N_X7_X0_X32_7_X7_X0_X32_M0_g
+ N_X7_X0_27_X7_X0_X32_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X0_X32_M1 N_X7_X0_28_X7_X0_X32_M1_d N_30_X7_X0_X32_M1_g
+ N_RESULT1_X7_X0_X32_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X0_X32_M2 N_X7_X0_X32_7_X7_X0_X32_M2_d N_30_X7_X0_X32_M2_g
+ N_GROUND_X7_X0_X32_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X0_X32_M3 N_RESULT1_X7_X0_X32_M3_d N_30_X7_X0_X32_M3_g
+ N_X7_X0_27_X7_X0_X32_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_X32_M4 N_X7_X0_28_X7_X0_X32_M4_d N_X7_X0_X32_7_X7_X0_X32_M4_g
+ N_RESULT1_X7_X0_X32_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_X32_M5 N_X7_X0_X32_7_X7_X0_X32_M5_d N_30_X7_X0_X32_M5_g
+ N_VDD_X7_X0_X32_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_X33_M0 N_X7_X0_28_X7_X0_X33_M0_d N_X7_X0_X33_7_X7_X0_X33_M0_g
+ N_X7_X0_26_X7_X0_X33_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X0_X33_M1 N_X7_X0_24_X7_X0_X33_M1_d N_29_X7_X0_X33_M1_g
+ N_X7_X0_28_X7_X0_X33_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X0_X33_M2 N_X7_X0_X33_7_X7_X0_X33_M2_d N_29_X7_X0_X33_M2_g
+ N_GROUND_X7_X0_X33_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X0_X33_M3 N_X7_X0_28_X7_X0_X33_M3_d N_29_X7_X0_X33_M3_g
+ N_X7_X0_26_X7_X0_X33_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_X33_M4 N_X7_X0_24_X7_X0_X33_M4_d N_X7_X0_X33_7_X7_X0_X33_M4_g
+ N_X7_X0_28_X7_X0_X33_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_X33_M5 N_X7_X0_X33_7_X7_X0_X33_M5_d N_29_X7_X0_X33_M5_g
+ N_VDD_X7_X0_X33_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_X34_M0 X7_X0_X34_7 N_X7_47_X7_X0_X34_M0_g N_X7_X0_X34_6_X7_X0_X34_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX7_X0_X34_M1 N_GROUND_X7_X0_X34_M1_d N_X7_48_X7_X0_X34_M1_g X7_X0_X34_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX7_X0_X34_M2 N_X7_X0_26_X7_X0_X34_M2_d N_X7_X0_X34_6_X7_X0_X34_M2_g
+ N_GROUND_X7_X0_X34_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X0_X34_M3 N_X7_X0_X34_6_X7_X0_X34_M3_d N_X7_47_X7_X0_X34_M3_g
+ N_VDD_X7_X0_X34_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_X34_M4 N_VDD_X7_X0_X34_M4_d N_X7_48_X7_X0_X34_M4_g
+ N_X7_X0_X34_6_X7_X0_X34_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X0_X34_M5 N_X7_X0_26_X7_X0_X34_M5_d N_X7_X0_X34_6_X7_X0_X34_M5_g
+ N_VDD_X7_X0_X34_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X0_X0_M0 N_GROUND_X7_X1_X0_X0_M0_d N_X7_X1_X0_X0_11_X7_X1_X0_X0_M0_g
+ N_X7_X1_30_X7_X1_X0_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M1 N_X7_X1_X0_X0_7_X7_X1_X0_X0_M1_d
+ N_X7_X1_X0_X0_10_X7_X1_X0_X0_M1_g N_GROUND_X7_X1_X0_X0_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M2 X7_X1_X0_X0_8 N_X7_X1_X0_X0_15_X7_X1_X0_X0_M2_g
+ N_X7_X1_X0_X0_7_X7_X1_X0_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M3 N_GROUND_X7_X1_X0_X0_M3_d N_X7_X1_X0_X0_16_X7_X1_X0_X0_M3_g
+ X7_X1_X0_X0_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M4 X7_X1_X0_X0_9 N_X7_X1_X0_X0_14_X7_X1_X0_X0_M4_g
+ N_GROUND_X7_X1_X0_X0_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M5 N_X7_X1_X0_X0_10_X7_X1_X0_X0_M5_d
+ N_X7_X1_X0_X0_15_X7_X1_X0_X0_M5_g X7_X1_X0_X0_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M6 N_GROUND_X7_X1_X0_X0_M6_d N_X7_X1_X0_X0_7_X7_X1_X0_X0_M6_g
+ N_X7_X1_X0_X0_10_X7_X1_X0_X0_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M7 N_X7_X1_X0_X0_11_X7_X1_X0_X0_M7_d N_X7_X1_30_X7_X1_X0_X0_M7_g
+ N_GROUND_X7_X1_X0_X0_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M8 X7_X1_X0_X0_12 N_CLK_X7_X1_X0_X0_M8_g
+ N_X7_X1_X0_X0_11_X7_X1_X0_X0_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M9 N_GROUND_X7_X1_X0_X0_M9_d N_X7_X1_X0_X0_10_X7_X1_X0_X0_M9_g
+ X7_X1_X0_X0_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M10 X7_X1_X0_X0_13 N_X7_X1_X0_X0_7_X7_X1_X0_X0_M10_g
+ N_GROUND_X7_X1_X0_X0_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M11 N_X7_X1_30_X7_X1_X0_X0_M11_d N_CLK_X7_X1_X0_X0_M11_g
+ X7_X1_X0_X0_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M12 N_GROUND_X7_X1_X0_X0_M12_d N_X7_X1_X0_X0_16_X7_X1_X0_X0_M12_g
+ N_X7_X1_X0_X0_14_X7_X1_X0_X0_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M13 N_X7_X1_X0_X0_15_X7_X1_X0_X0_M13_d N_CLK_X7_X1_X0_X0_M13_g
+ N_GROUND_X7_X1_X0_X0_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M14 N_VDD_X7_X1_X0_X0_M14_d N_X7_X1_X0_X0_16_X7_X1_X0_X0_M14_g
+ N_X7_X1_X0_X0_14_X7_X1_X0_X0_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M15 N_X7_X1_X0_X0_15_X7_X1_X0_X0_M15_d N_CLK_X7_X1_X0_X0_M15_g
+ N_VDD_X7_X1_X0_X0_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M16 N_VDD_X7_X1_X0_X0_M16_d N_X7_X1_X0_X0_7_X7_X1_X0_X0_M16_g
+ N_X7_X1_X0_X0_10_X7_X1_X0_X0_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M17 N_X7_X1_X0_X0_7_X7_X1_X0_X0_M17_d
+ N_X7_X1_X0_X0_10_X7_X1_X0_X0_M17_g N_VDD_X7_X1_X0_X0_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M18 N_VDD_X7_X1_X0_X0_M18_d N_X7_X1_X0_X0_11_X7_X1_X0_X0_M18_g
+ N_X7_X1_30_X7_X1_X0_X0_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_M19 N_X7_X1_X0_X0_11_X7_X1_X0_X0_M19_d N_X7_X1_30_X7_X1_X0_X0_M19_g
+ N_VDD_X7_X1_X0_X0_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_X20_M0 N_X7_X1_X0_X0_16_X7_X1_X0_X0_X20_M0_d
+ N_X7_X1_X0_X0_X20_7_X7_X1_X0_X0_X20_M0_g N_X7_X1_30_X7_X1_X0_X0_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_X20_M1 N_14_X7_X1_X0_X0_X20_M1_d N_X7_X1_22_X7_X1_X0_X0_X20_M1_g
+ N_X7_X1_X0_X0_16_X7_X1_X0_X0_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_X20_M2 N_X7_X1_X0_X0_X20_7_X7_X1_X0_X0_X20_M2_d
+ N_X7_X1_22_X7_X1_X0_X0_X20_M2_g N_GROUND_X7_X1_X0_X0_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X0_X20_M3 N_X7_X1_X0_X0_16_X7_X1_X0_X0_X20_M3_d
+ N_X7_X1_22_X7_X1_X0_X0_X20_M3_g N_X7_X1_30_X7_X1_X0_X0_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X0_X0_X20_M4 N_14_X7_X1_X0_X0_X20_M4_d
+ N_X7_X1_X0_X0_X20_7_X7_X1_X0_X0_X20_M4_g N_X7_X1_X0_X0_16_X7_X1_X0_X0_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X0_X0_X20_M5 N_X7_X1_X0_X0_X20_7_X7_X1_X0_X0_X20_M5_d
+ N_X7_X1_22_X7_X1_X0_X0_X20_M5_g N_VDD_X7_X1_X0_X0_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX7_X1_X0_X1_M0 N_GROUND_X7_X1_X0_X1_M0_d N_X7_X1_X0_X1_11_X7_X1_X0_X1_M0_g
+ N_X7_X1_31_X7_X1_X0_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M1 N_X7_X1_X0_X1_7_X7_X1_X0_X1_M1_d
+ N_X7_X1_X0_X1_10_X7_X1_X0_X1_M1_g N_GROUND_X7_X1_X0_X1_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M2 X7_X1_X0_X1_8 N_X7_X1_X0_X1_15_X7_X1_X0_X1_M2_g
+ N_X7_X1_X0_X1_7_X7_X1_X0_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M3 N_GROUND_X7_X1_X0_X1_M3_d N_X7_X1_X0_X1_16_X7_X1_X0_X1_M3_g
+ X7_X1_X0_X1_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M4 X7_X1_X0_X1_9 N_X7_X1_X0_X1_14_X7_X1_X0_X1_M4_g
+ N_GROUND_X7_X1_X0_X1_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M5 N_X7_X1_X0_X1_10_X7_X1_X0_X1_M5_d
+ N_X7_X1_X0_X1_15_X7_X1_X0_X1_M5_g X7_X1_X0_X1_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M6 N_GROUND_X7_X1_X0_X1_M6_d N_X7_X1_X0_X1_7_X7_X1_X0_X1_M6_g
+ N_X7_X1_X0_X1_10_X7_X1_X0_X1_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M7 N_X7_X1_X0_X1_11_X7_X1_X0_X1_M7_d N_X7_X1_31_X7_X1_X0_X1_M7_g
+ N_GROUND_X7_X1_X0_X1_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M8 X7_X1_X0_X1_12 N_CLK_X7_X1_X0_X1_M8_g
+ N_X7_X1_X0_X1_11_X7_X1_X0_X1_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M9 N_GROUND_X7_X1_X0_X1_M9_d N_X7_X1_X0_X1_10_X7_X1_X0_X1_M9_g
+ X7_X1_X0_X1_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M10 X7_X1_X0_X1_13 N_X7_X1_X0_X1_7_X7_X1_X0_X1_M10_g
+ N_GROUND_X7_X1_X0_X1_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M11 N_X7_X1_31_X7_X1_X0_X1_M11_d N_CLK_X7_X1_X0_X1_M11_g
+ X7_X1_X0_X1_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M12 N_GROUND_X7_X1_X0_X1_M12_d N_X7_X1_X0_X1_16_X7_X1_X0_X1_M12_g
+ N_X7_X1_X0_X1_14_X7_X1_X0_X1_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M13 N_X7_X1_X0_X1_15_X7_X1_X0_X1_M13_d N_CLK_X7_X1_X0_X1_M13_g
+ N_GROUND_X7_X1_X0_X1_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M14 N_VDD_X7_X1_X0_X1_M14_d N_X7_X1_X0_X1_16_X7_X1_X0_X1_M14_g
+ N_X7_X1_X0_X1_14_X7_X1_X0_X1_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M15 N_X7_X1_X0_X1_15_X7_X1_X0_X1_M15_d N_CLK_X7_X1_X0_X1_M15_g
+ N_VDD_X7_X1_X0_X1_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M16 N_VDD_X7_X1_X0_X1_M16_d N_X7_X1_X0_X1_7_X7_X1_X0_X1_M16_g
+ N_X7_X1_X0_X1_10_X7_X1_X0_X1_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M17 N_X7_X1_X0_X1_7_X7_X1_X0_X1_M17_d
+ N_X7_X1_X0_X1_10_X7_X1_X0_X1_M17_g N_VDD_X7_X1_X0_X1_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M18 N_VDD_X7_X1_X0_X1_M18_d N_X7_X1_X0_X1_11_X7_X1_X0_X1_M18_g
+ N_X7_X1_31_X7_X1_X0_X1_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_M19 N_X7_X1_X0_X1_11_X7_X1_X0_X1_M19_d N_X7_X1_31_X7_X1_X0_X1_M19_g
+ N_VDD_X7_X1_X0_X1_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_X20_M0 N_X7_X1_X0_X1_16_X7_X1_X0_X1_X20_M0_d
+ N_X7_X1_X0_X1_X20_7_X7_X1_X0_X1_X20_M0_g N_X7_X1_31_X7_X1_X0_X1_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_X20_M1 N_14_X7_X1_X0_X1_X20_M1_d N_X7_X1_23_X7_X1_X0_X1_X20_M1_g
+ N_X7_X1_X0_X1_16_X7_X1_X0_X1_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_X20_M2 N_X7_X1_X0_X1_X20_7_X7_X1_X0_X1_X20_M2_d
+ N_X7_X1_23_X7_X1_X0_X1_X20_M2_g N_GROUND_X7_X1_X0_X1_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX7_X1_X0_X1_X20_M3 N_X7_X1_X0_X1_16_X7_X1_X0_X1_X20_M3_d
+ N_X7_X1_23_X7_X1_X0_X1_X20_M3_g N_X7_X1_31_X7_X1_X0_X1_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X0_X1_X20_M4 N_14_X7_X1_X0_X1_X20_M4_d
+ N_X7_X1_X0_X1_X20_7_X7_X1_X0_X1_X20_M4_g N_X7_X1_X0_X1_16_X7_X1_X0_X1_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X0_X1_X20_M5 N_X7_X1_X0_X1_X20_7_X7_X1_X0_X1_X20_M5_d
+ N_X7_X1_23_X7_X1_X0_X1_X20_M5_g N_VDD_X7_X1_X0_X1_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX7_X1_X1_X0_M0 N_GROUND_X7_X1_X1_X0_M0_d N_X7_X1_X1_X0_11_X7_X1_X1_X0_M0_g
+ N_X7_X1_32_X7_X1_X1_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M1 N_X7_X1_X1_X0_7_X7_X1_X1_X0_M1_d
+ N_X7_X1_X1_X0_10_X7_X1_X1_X0_M1_g N_GROUND_X7_X1_X1_X0_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M2 X7_X1_X1_X0_8 N_X7_X1_X1_X0_15_X7_X1_X1_X0_M2_g
+ N_X7_X1_X1_X0_7_X7_X1_X1_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M3 N_GROUND_X7_X1_X1_X0_M3_d N_X7_X1_X1_X0_16_X7_X1_X1_X0_M3_g
+ X7_X1_X1_X0_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M4 X7_X1_X1_X0_9 N_X7_X1_X1_X0_14_X7_X1_X1_X0_M4_g
+ N_GROUND_X7_X1_X1_X0_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M5 N_X7_X1_X1_X0_10_X7_X1_X1_X0_M5_d
+ N_X7_X1_X1_X0_15_X7_X1_X1_X0_M5_g X7_X1_X1_X0_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M6 N_GROUND_X7_X1_X1_X0_M6_d N_X7_X1_X1_X0_7_X7_X1_X1_X0_M6_g
+ N_X7_X1_X1_X0_10_X7_X1_X1_X0_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M7 N_X7_X1_X1_X0_11_X7_X1_X1_X0_M7_d N_X7_X1_32_X7_X1_X1_X0_M7_g
+ N_GROUND_X7_X1_X1_X0_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M8 X7_X1_X1_X0_12 N_CLK_X7_X1_X1_X0_M8_g
+ N_X7_X1_X1_X0_11_X7_X1_X1_X0_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M9 N_GROUND_X7_X1_X1_X0_M9_d N_X7_X1_X1_X0_10_X7_X1_X1_X0_M9_g
+ X7_X1_X1_X0_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M10 X7_X1_X1_X0_13 N_X7_X1_X1_X0_7_X7_X1_X1_X0_M10_g
+ N_GROUND_X7_X1_X1_X0_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M11 N_X7_X1_32_X7_X1_X1_X0_M11_d N_CLK_X7_X1_X1_X0_M11_g
+ X7_X1_X1_X0_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M12 N_GROUND_X7_X1_X1_X0_M12_d N_X7_X1_X1_X0_16_X7_X1_X1_X0_M12_g
+ N_X7_X1_X1_X0_14_X7_X1_X1_X0_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M13 N_X7_X1_X1_X0_15_X7_X1_X1_X0_M13_d N_CLK_X7_X1_X1_X0_M13_g
+ N_GROUND_X7_X1_X1_X0_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M14 N_VDD_X7_X1_X1_X0_M14_d N_X7_X1_X1_X0_16_X7_X1_X1_X0_M14_g
+ N_X7_X1_X1_X0_14_X7_X1_X1_X0_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M15 N_X7_X1_X1_X0_15_X7_X1_X1_X0_M15_d N_CLK_X7_X1_X1_X0_M15_g
+ N_VDD_X7_X1_X1_X0_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M16 N_VDD_X7_X1_X1_X0_M16_d N_X7_X1_X1_X0_7_X7_X1_X1_X0_M16_g
+ N_X7_X1_X1_X0_10_X7_X1_X1_X0_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M17 N_X7_X1_X1_X0_7_X7_X1_X1_X0_M17_d
+ N_X7_X1_X1_X0_10_X7_X1_X1_X0_M17_g N_VDD_X7_X1_X1_X0_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M18 N_VDD_X7_X1_X1_X0_M18_d N_X7_X1_X1_X0_11_X7_X1_X1_X0_M18_g
+ N_X7_X1_32_X7_X1_X1_X0_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_M19 N_X7_X1_X1_X0_11_X7_X1_X1_X0_M19_d N_X7_X1_32_X7_X1_X1_X0_M19_g
+ N_VDD_X7_X1_X1_X0_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_X20_M0 N_X7_X1_X1_X0_16_X7_X1_X1_X0_X20_M0_d
+ N_X7_X1_X1_X0_X20_7_X7_X1_X1_X0_X20_M0_g N_X7_X1_32_X7_X1_X1_X0_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_X20_M1 N_14_X7_X1_X1_X0_X20_M1_d N_X7_X1_24_X7_X1_X1_X0_X20_M1_g
+ N_X7_X1_X1_X0_16_X7_X1_X1_X0_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_X20_M2 N_X7_X1_X1_X0_X20_7_X7_X1_X1_X0_X20_M2_d
+ N_X7_X1_24_X7_X1_X1_X0_X20_M2_g N_GROUND_X7_X1_X1_X0_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X0_X20_M3 N_X7_X1_X1_X0_16_X7_X1_X1_X0_X20_M3_d
+ N_X7_X1_24_X7_X1_X1_X0_X20_M3_g N_X7_X1_32_X7_X1_X1_X0_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X1_X0_X20_M4 N_14_X7_X1_X1_X0_X20_M4_d
+ N_X7_X1_X1_X0_X20_7_X7_X1_X1_X0_X20_M4_g N_X7_X1_X1_X0_16_X7_X1_X1_X0_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X1_X0_X20_M5 N_X7_X1_X1_X0_X20_7_X7_X1_X1_X0_X20_M5_d
+ N_X7_X1_24_X7_X1_X1_X0_X20_M5_g N_VDD_X7_X1_X1_X0_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX7_X1_X1_X1_M0 N_GROUND_X7_X1_X1_X1_M0_d N_X7_X1_X1_X1_11_X7_X1_X1_X1_M0_g
+ N_X7_X1_33_X7_X1_X1_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M1 N_X7_X1_X1_X1_7_X7_X1_X1_X1_M1_d
+ N_X7_X1_X1_X1_10_X7_X1_X1_X1_M1_g N_GROUND_X7_X1_X1_X1_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M2 X7_X1_X1_X1_8 N_X7_X1_X1_X1_15_X7_X1_X1_X1_M2_g
+ N_X7_X1_X1_X1_7_X7_X1_X1_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M3 N_GROUND_X7_X1_X1_X1_M3_d N_X7_X1_X1_X1_16_X7_X1_X1_X1_M3_g
+ X7_X1_X1_X1_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M4 X7_X1_X1_X1_9 N_X7_X1_X1_X1_14_X7_X1_X1_X1_M4_g
+ N_GROUND_X7_X1_X1_X1_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M5 N_X7_X1_X1_X1_10_X7_X1_X1_X1_M5_d
+ N_X7_X1_X1_X1_15_X7_X1_X1_X1_M5_g X7_X1_X1_X1_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M6 N_GROUND_X7_X1_X1_X1_M6_d N_X7_X1_X1_X1_7_X7_X1_X1_X1_M6_g
+ N_X7_X1_X1_X1_10_X7_X1_X1_X1_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M7 N_X7_X1_X1_X1_11_X7_X1_X1_X1_M7_d N_X7_X1_33_X7_X1_X1_X1_M7_g
+ N_GROUND_X7_X1_X1_X1_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M8 X7_X1_X1_X1_12 N_CLK_X7_X1_X1_X1_M8_g
+ N_X7_X1_X1_X1_11_X7_X1_X1_X1_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M9 N_GROUND_X7_X1_X1_X1_M9_d N_X7_X1_X1_X1_10_X7_X1_X1_X1_M9_g
+ X7_X1_X1_X1_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M10 X7_X1_X1_X1_13 N_X7_X1_X1_X1_7_X7_X1_X1_X1_M10_g
+ N_GROUND_X7_X1_X1_X1_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M11 N_X7_X1_33_X7_X1_X1_X1_M11_d N_CLK_X7_X1_X1_X1_M11_g
+ X7_X1_X1_X1_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M12 N_GROUND_X7_X1_X1_X1_M12_d N_X7_X1_X1_X1_16_X7_X1_X1_X1_M12_g
+ N_X7_X1_X1_X1_14_X7_X1_X1_X1_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M13 N_X7_X1_X1_X1_15_X7_X1_X1_X1_M13_d N_CLK_X7_X1_X1_X1_M13_g
+ N_GROUND_X7_X1_X1_X1_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M14 N_VDD_X7_X1_X1_X1_M14_d N_X7_X1_X1_X1_16_X7_X1_X1_X1_M14_g
+ N_X7_X1_X1_X1_14_X7_X1_X1_X1_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M15 N_X7_X1_X1_X1_15_X7_X1_X1_X1_M15_d N_CLK_X7_X1_X1_X1_M15_g
+ N_VDD_X7_X1_X1_X1_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M16 N_VDD_X7_X1_X1_X1_M16_d N_X7_X1_X1_X1_7_X7_X1_X1_X1_M16_g
+ N_X7_X1_X1_X1_10_X7_X1_X1_X1_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M17 N_X7_X1_X1_X1_7_X7_X1_X1_X1_M17_d
+ N_X7_X1_X1_X1_10_X7_X1_X1_X1_M17_g N_VDD_X7_X1_X1_X1_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M18 N_VDD_X7_X1_X1_X1_M18_d N_X7_X1_X1_X1_11_X7_X1_X1_X1_M18_g
+ N_X7_X1_33_X7_X1_X1_X1_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_M19 N_X7_X1_X1_X1_11_X7_X1_X1_X1_M19_d N_X7_X1_33_X7_X1_X1_X1_M19_g
+ N_VDD_X7_X1_X1_X1_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_X20_M0 N_X7_X1_X1_X1_16_X7_X1_X1_X1_X20_M0_d
+ N_X7_X1_X1_X1_X20_7_X7_X1_X1_X1_X20_M0_g N_X7_X1_33_X7_X1_X1_X1_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_X20_M1 N_14_X7_X1_X1_X1_X20_M1_d N_X7_X1_25_X7_X1_X1_X1_X20_M1_g
+ N_X7_X1_X1_X1_16_X7_X1_X1_X1_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_X20_M2 N_X7_X1_X1_X1_X20_7_X7_X1_X1_X1_X20_M2_d
+ N_X7_X1_25_X7_X1_X1_X1_X20_M2_g N_GROUND_X7_X1_X1_X1_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX7_X1_X1_X1_X20_M3 N_X7_X1_X1_X1_16_X7_X1_X1_X1_X20_M3_d
+ N_X7_X1_25_X7_X1_X1_X1_X20_M3_g N_X7_X1_33_X7_X1_X1_X1_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X1_X1_X20_M4 N_14_X7_X1_X1_X1_X20_M4_d
+ N_X7_X1_X1_X1_X20_7_X7_X1_X1_X1_X20_M4_g N_X7_X1_X1_X1_16_X7_X1_X1_X1_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X1_X1_X20_M5 N_X7_X1_X1_X1_X20_7_X7_X1_X1_X1_X20_M5_d
+ N_X7_X1_25_X7_X1_X1_X1_X20_M5_g N_VDD_X7_X1_X1_X1_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX7_X1_X2_X0_M0 N_GROUND_X7_X1_X2_X0_M0_d N_X7_X1_X2_X0_11_X7_X1_X2_X0_M0_g
+ N_X7_X1_34_X7_X1_X2_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M1 N_X7_X1_X2_X0_7_X7_X1_X2_X0_M1_d
+ N_X7_X1_X2_X0_10_X7_X1_X2_X0_M1_g N_GROUND_X7_X1_X2_X0_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M2 X7_X1_X2_X0_8 N_X7_X1_X2_X0_15_X7_X1_X2_X0_M2_g
+ N_X7_X1_X2_X0_7_X7_X1_X2_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M3 N_GROUND_X7_X1_X2_X0_M3_d N_X7_X1_X2_X0_16_X7_X1_X2_X0_M3_g
+ X7_X1_X2_X0_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M4 X7_X1_X2_X0_9 N_X7_X1_X2_X0_14_X7_X1_X2_X0_M4_g
+ N_GROUND_X7_X1_X2_X0_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M5 N_X7_X1_X2_X0_10_X7_X1_X2_X0_M5_d
+ N_X7_X1_X2_X0_15_X7_X1_X2_X0_M5_g X7_X1_X2_X0_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M6 N_GROUND_X7_X1_X2_X0_M6_d N_X7_X1_X2_X0_7_X7_X1_X2_X0_M6_g
+ N_X7_X1_X2_X0_10_X7_X1_X2_X0_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M7 N_X7_X1_X2_X0_11_X7_X1_X2_X0_M7_d N_X7_X1_34_X7_X1_X2_X0_M7_g
+ N_GROUND_X7_X1_X2_X0_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M8 X7_X1_X2_X0_12 N_CLK_X7_X1_X2_X0_M8_g
+ N_X7_X1_X2_X0_11_X7_X1_X2_X0_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M9 N_GROUND_X7_X1_X2_X0_M9_d N_X7_X1_X2_X0_10_X7_X1_X2_X0_M9_g
+ X7_X1_X2_X0_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M10 X7_X1_X2_X0_13 N_X7_X1_X2_X0_7_X7_X1_X2_X0_M10_g
+ N_GROUND_X7_X1_X2_X0_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M11 N_X7_X1_34_X7_X1_X2_X0_M11_d N_CLK_X7_X1_X2_X0_M11_g
+ X7_X1_X2_X0_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M12 N_GROUND_X7_X1_X2_X0_M12_d N_X7_X1_X2_X0_16_X7_X1_X2_X0_M12_g
+ N_X7_X1_X2_X0_14_X7_X1_X2_X0_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M13 N_X7_X1_X2_X0_15_X7_X1_X2_X0_M13_d N_CLK_X7_X1_X2_X0_M13_g
+ N_GROUND_X7_X1_X2_X0_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M14 N_VDD_X7_X1_X2_X0_M14_d N_X7_X1_X2_X0_16_X7_X1_X2_X0_M14_g
+ N_X7_X1_X2_X0_14_X7_X1_X2_X0_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M15 N_X7_X1_X2_X0_15_X7_X1_X2_X0_M15_d N_CLK_X7_X1_X2_X0_M15_g
+ N_VDD_X7_X1_X2_X0_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M16 N_VDD_X7_X1_X2_X0_M16_d N_X7_X1_X2_X0_7_X7_X1_X2_X0_M16_g
+ N_X7_X1_X2_X0_10_X7_X1_X2_X0_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M17 N_X7_X1_X2_X0_7_X7_X1_X2_X0_M17_d
+ N_X7_X1_X2_X0_10_X7_X1_X2_X0_M17_g N_VDD_X7_X1_X2_X0_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M18 N_VDD_X7_X1_X2_X0_M18_d N_X7_X1_X2_X0_11_X7_X1_X2_X0_M18_g
+ N_X7_X1_34_X7_X1_X2_X0_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_M19 N_X7_X1_X2_X0_11_X7_X1_X2_X0_M19_d N_X7_X1_34_X7_X1_X2_X0_M19_g
+ N_VDD_X7_X1_X2_X0_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_X20_M0 N_X7_X1_X2_X0_16_X7_X1_X2_X0_X20_M0_d
+ N_X7_X1_X2_X0_X20_7_X7_X1_X2_X0_X20_M0_g N_X7_X1_34_X7_X1_X2_X0_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_X20_M1 N_14_X7_X1_X2_X0_X20_M1_d N_X7_X1_26_X7_X1_X2_X0_X20_M1_g
+ N_X7_X1_X2_X0_16_X7_X1_X2_X0_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_X20_M2 N_X7_X1_X2_X0_X20_7_X7_X1_X2_X0_X20_M2_d
+ N_X7_X1_26_X7_X1_X2_X0_X20_M2_g N_GROUND_X7_X1_X2_X0_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X0_X20_M3 N_X7_X1_X2_X0_16_X7_X1_X2_X0_X20_M3_d
+ N_X7_X1_26_X7_X1_X2_X0_X20_M3_g N_X7_X1_34_X7_X1_X2_X0_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X2_X0_X20_M4 N_14_X7_X1_X2_X0_X20_M4_d
+ N_X7_X1_X2_X0_X20_7_X7_X1_X2_X0_X20_M4_g N_X7_X1_X2_X0_16_X7_X1_X2_X0_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X2_X0_X20_M5 N_X7_X1_X2_X0_X20_7_X7_X1_X2_X0_X20_M5_d
+ N_X7_X1_26_X7_X1_X2_X0_X20_M5_g N_VDD_X7_X1_X2_X0_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX7_X1_X2_X1_M0 N_GROUND_X7_X1_X2_X1_M0_d N_X7_X1_X2_X1_11_X7_X1_X2_X1_M0_g
+ N_X7_X1_35_X7_X1_X2_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M1 N_X7_X1_X2_X1_7_X7_X1_X2_X1_M1_d
+ N_X7_X1_X2_X1_10_X7_X1_X2_X1_M1_g N_GROUND_X7_X1_X2_X1_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M2 X7_X1_X2_X1_8 N_X7_X1_X2_X1_15_X7_X1_X2_X1_M2_g
+ N_X7_X1_X2_X1_7_X7_X1_X2_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M3 N_GROUND_X7_X1_X2_X1_M3_d N_X7_X1_X2_X1_16_X7_X1_X2_X1_M3_g
+ X7_X1_X2_X1_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M4 X7_X1_X2_X1_9 N_X7_X1_X2_X1_14_X7_X1_X2_X1_M4_g
+ N_GROUND_X7_X1_X2_X1_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M5 N_X7_X1_X2_X1_10_X7_X1_X2_X1_M5_d
+ N_X7_X1_X2_X1_15_X7_X1_X2_X1_M5_g X7_X1_X2_X1_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M6 N_GROUND_X7_X1_X2_X1_M6_d N_X7_X1_X2_X1_7_X7_X1_X2_X1_M6_g
+ N_X7_X1_X2_X1_10_X7_X1_X2_X1_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M7 N_X7_X1_X2_X1_11_X7_X1_X2_X1_M7_d N_X7_X1_35_X7_X1_X2_X1_M7_g
+ N_GROUND_X7_X1_X2_X1_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M8 X7_X1_X2_X1_12 N_CLK_X7_X1_X2_X1_M8_g
+ N_X7_X1_X2_X1_11_X7_X1_X2_X1_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M9 N_GROUND_X7_X1_X2_X1_M9_d N_X7_X1_X2_X1_10_X7_X1_X2_X1_M9_g
+ X7_X1_X2_X1_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M10 X7_X1_X2_X1_13 N_X7_X1_X2_X1_7_X7_X1_X2_X1_M10_g
+ N_GROUND_X7_X1_X2_X1_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M11 N_X7_X1_35_X7_X1_X2_X1_M11_d N_CLK_X7_X1_X2_X1_M11_g
+ X7_X1_X2_X1_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M12 N_GROUND_X7_X1_X2_X1_M12_d N_X7_X1_X2_X1_16_X7_X1_X2_X1_M12_g
+ N_X7_X1_X2_X1_14_X7_X1_X2_X1_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M13 N_X7_X1_X2_X1_15_X7_X1_X2_X1_M13_d N_CLK_X7_X1_X2_X1_M13_g
+ N_GROUND_X7_X1_X2_X1_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M14 N_VDD_X7_X1_X2_X1_M14_d N_X7_X1_X2_X1_16_X7_X1_X2_X1_M14_g
+ N_X7_X1_X2_X1_14_X7_X1_X2_X1_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M15 N_X7_X1_X2_X1_15_X7_X1_X2_X1_M15_d N_CLK_X7_X1_X2_X1_M15_g
+ N_VDD_X7_X1_X2_X1_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M16 N_VDD_X7_X1_X2_X1_M16_d N_X7_X1_X2_X1_7_X7_X1_X2_X1_M16_g
+ N_X7_X1_X2_X1_10_X7_X1_X2_X1_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M17 N_X7_X1_X2_X1_7_X7_X1_X2_X1_M17_d
+ N_X7_X1_X2_X1_10_X7_X1_X2_X1_M17_g N_VDD_X7_X1_X2_X1_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M18 N_VDD_X7_X1_X2_X1_M18_d N_X7_X1_X2_X1_11_X7_X1_X2_X1_M18_g
+ N_X7_X1_35_X7_X1_X2_X1_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_M19 N_X7_X1_X2_X1_11_X7_X1_X2_X1_M19_d N_X7_X1_35_X7_X1_X2_X1_M19_g
+ N_VDD_X7_X1_X2_X1_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_X20_M0 N_X7_X1_X2_X1_16_X7_X1_X2_X1_X20_M0_d
+ N_X7_X1_X2_X1_X20_7_X7_X1_X2_X1_X20_M0_g N_X7_X1_35_X7_X1_X2_X1_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_X20_M1 N_14_X7_X1_X2_X1_X20_M1_d N_X7_X1_27_X7_X1_X2_X1_X20_M1_g
+ N_X7_X1_X2_X1_16_X7_X1_X2_X1_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_X20_M2 N_X7_X1_X2_X1_X20_7_X7_X1_X2_X1_X20_M2_d
+ N_X7_X1_27_X7_X1_X2_X1_X20_M2_g N_GROUND_X7_X1_X2_X1_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX7_X1_X2_X1_X20_M3 N_X7_X1_X2_X1_16_X7_X1_X2_X1_X20_M3_d
+ N_X7_X1_27_X7_X1_X2_X1_X20_M3_g N_X7_X1_35_X7_X1_X2_X1_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X2_X1_X20_M4 N_14_X7_X1_X2_X1_X20_M4_d
+ N_X7_X1_X2_X1_X20_7_X7_X1_X2_X1_X20_M4_g N_X7_X1_X2_X1_16_X7_X1_X2_X1_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X2_X1_X20_M5 N_X7_X1_X2_X1_X20_7_X7_X1_X2_X1_X20_M5_d
+ N_X7_X1_27_X7_X1_X2_X1_X20_M5_g N_VDD_X7_X1_X2_X1_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX7_X1_X3_X0_M0 N_GROUND_X7_X1_X3_X0_M0_d N_X7_X1_X3_X0_11_X7_X1_X3_X0_M0_g
+ N_X7_X1_36_X7_X1_X3_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M1 N_X7_X1_X3_X0_7_X7_X1_X3_X0_M1_d
+ N_X7_X1_X3_X0_10_X7_X1_X3_X0_M1_g N_GROUND_X7_X1_X3_X0_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M2 X7_X1_X3_X0_8 N_X7_X1_X3_X0_15_X7_X1_X3_X0_M2_g
+ N_X7_X1_X3_X0_7_X7_X1_X3_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M3 N_GROUND_X7_X1_X3_X0_M3_d N_X7_X1_X3_X0_16_X7_X1_X3_X0_M3_g
+ X7_X1_X3_X0_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M4 X7_X1_X3_X0_9 N_X7_X1_X3_X0_14_X7_X1_X3_X0_M4_g
+ N_GROUND_X7_X1_X3_X0_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M5 N_X7_X1_X3_X0_10_X7_X1_X3_X0_M5_d
+ N_X7_X1_X3_X0_15_X7_X1_X3_X0_M5_g X7_X1_X3_X0_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M6 N_GROUND_X7_X1_X3_X0_M6_d N_X7_X1_X3_X0_7_X7_X1_X3_X0_M6_g
+ N_X7_X1_X3_X0_10_X7_X1_X3_X0_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M7 N_X7_X1_X3_X0_11_X7_X1_X3_X0_M7_d N_X7_X1_36_X7_X1_X3_X0_M7_g
+ N_GROUND_X7_X1_X3_X0_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M8 X7_X1_X3_X0_12 N_CLK_X7_X1_X3_X0_M8_g
+ N_X7_X1_X3_X0_11_X7_X1_X3_X0_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M9 N_GROUND_X7_X1_X3_X0_M9_d N_X7_X1_X3_X0_10_X7_X1_X3_X0_M9_g
+ X7_X1_X3_X0_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M10 X7_X1_X3_X0_13 N_X7_X1_X3_X0_7_X7_X1_X3_X0_M10_g
+ N_GROUND_X7_X1_X3_X0_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M11 N_X7_X1_36_X7_X1_X3_X0_M11_d N_CLK_X7_X1_X3_X0_M11_g
+ X7_X1_X3_X0_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M12 N_GROUND_X7_X1_X3_X0_M12_d N_X7_X1_X3_X0_16_X7_X1_X3_X0_M12_g
+ N_X7_X1_X3_X0_14_X7_X1_X3_X0_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M13 N_X7_X1_X3_X0_15_X7_X1_X3_X0_M13_d N_CLK_X7_X1_X3_X0_M13_g
+ N_GROUND_X7_X1_X3_X0_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M14 N_VDD_X7_X1_X3_X0_M14_d N_X7_X1_X3_X0_16_X7_X1_X3_X0_M14_g
+ N_X7_X1_X3_X0_14_X7_X1_X3_X0_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M15 N_X7_X1_X3_X0_15_X7_X1_X3_X0_M15_d N_CLK_X7_X1_X3_X0_M15_g
+ N_VDD_X7_X1_X3_X0_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M16 N_VDD_X7_X1_X3_X0_M16_d N_X7_X1_X3_X0_7_X7_X1_X3_X0_M16_g
+ N_X7_X1_X3_X0_10_X7_X1_X3_X0_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M17 N_X7_X1_X3_X0_7_X7_X1_X3_X0_M17_d
+ N_X7_X1_X3_X0_10_X7_X1_X3_X0_M17_g N_VDD_X7_X1_X3_X0_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M18 N_VDD_X7_X1_X3_X0_M18_d N_X7_X1_X3_X0_11_X7_X1_X3_X0_M18_g
+ N_X7_X1_36_X7_X1_X3_X0_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_M19 N_X7_X1_X3_X0_11_X7_X1_X3_X0_M19_d N_X7_X1_36_X7_X1_X3_X0_M19_g
+ N_VDD_X7_X1_X3_X0_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_X20_M0 N_X7_X1_X3_X0_16_X7_X1_X3_X0_X20_M0_d
+ N_X7_X1_X3_X0_X20_7_X7_X1_X3_X0_X20_M0_g N_X7_X1_36_X7_X1_X3_X0_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_X20_M1 N_14_X7_X1_X3_X0_X20_M1_d N_X7_X1_28_X7_X1_X3_X0_X20_M1_g
+ N_X7_X1_X3_X0_16_X7_X1_X3_X0_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_X20_M2 N_X7_X1_X3_X0_X20_7_X7_X1_X3_X0_X20_M2_d
+ N_X7_X1_28_X7_X1_X3_X0_X20_M2_g N_GROUND_X7_X1_X3_X0_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X0_X20_M3 N_X7_X1_X3_X0_16_X7_X1_X3_X0_X20_M3_d
+ N_X7_X1_28_X7_X1_X3_X0_X20_M3_g N_X7_X1_36_X7_X1_X3_X0_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X3_X0_X20_M4 N_14_X7_X1_X3_X0_X20_M4_d
+ N_X7_X1_X3_X0_X20_7_X7_X1_X3_X0_X20_M4_g N_X7_X1_X3_X0_16_X7_X1_X3_X0_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X3_X0_X20_M5 N_X7_X1_X3_X0_X20_7_X7_X1_X3_X0_X20_M5_d
+ N_X7_X1_28_X7_X1_X3_X0_X20_M5_g N_VDD_X7_X1_X3_X0_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX7_X1_X3_X1_M0 N_GROUND_X7_X1_X3_X1_M0_d N_X7_X1_X3_X1_11_X7_X1_X3_X1_M0_g
+ N_X7_X1_37_X7_X1_X3_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M1 N_X7_X1_X3_X1_7_X7_X1_X3_X1_M1_d
+ N_X7_X1_X3_X1_10_X7_X1_X3_X1_M1_g N_GROUND_X7_X1_X3_X1_M0_d N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M2 X7_X1_X3_X1_8 N_X7_X1_X3_X1_15_X7_X1_X3_X1_M2_g
+ N_X7_X1_X3_X1_7_X7_X1_X3_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M3 N_GROUND_X7_X1_X3_X1_M3_d N_X7_X1_X3_X1_16_X7_X1_X3_X1_M3_g
+ X7_X1_X3_X1_8 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M4 X7_X1_X3_X1_9 N_X7_X1_X3_X1_14_X7_X1_X3_X1_M4_g
+ N_GROUND_X7_X1_X3_X1_M3_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M5 N_X7_X1_X3_X1_10_X7_X1_X3_X1_M5_d
+ N_X7_X1_X3_X1_15_X7_X1_X3_X1_M5_g X7_X1_X3_X1_9 N_GROUND_X0_M0_b NMOS
+ L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M6 N_GROUND_X7_X1_X3_X1_M6_d N_X7_X1_X3_X1_7_X7_X1_X3_X1_M6_g
+ N_X7_X1_X3_X1_10_X7_X1_X3_X1_M5_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M7 N_X7_X1_X3_X1_11_X7_X1_X3_X1_M7_d N_X7_X1_37_X7_X1_X3_X1_M7_g
+ N_GROUND_X7_X1_X3_X1_M6_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M8 X7_X1_X3_X1_12 N_CLK_X7_X1_X3_X1_M8_g
+ N_X7_X1_X3_X1_11_X7_X1_X3_X1_M8_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M9 N_GROUND_X7_X1_X3_X1_M9_d N_X7_X1_X3_X1_10_X7_X1_X3_X1_M9_g
+ X7_X1_X3_X1_12 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M10 X7_X1_X3_X1_13 N_X7_X1_X3_X1_7_X7_X1_X3_X1_M10_g
+ N_GROUND_X7_X1_X3_X1_M9_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M11 N_X7_X1_37_X7_X1_X3_X1_M11_d N_CLK_X7_X1_X3_X1_M11_g
+ X7_X1_X3_X1_13 N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M12 N_GROUND_X7_X1_X3_X1_M12_d N_X7_X1_X3_X1_16_X7_X1_X3_X1_M12_g
+ N_X7_X1_X3_X1_14_X7_X1_X3_X1_M12_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M13 N_X7_X1_X3_X1_15_X7_X1_X3_X1_M13_d N_CLK_X7_X1_X3_X1_M13_g
+ N_GROUND_X7_X1_X3_X1_M12_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M14 N_VDD_X7_X1_X3_X1_M14_d N_X7_X1_X3_X1_16_X7_X1_X3_X1_M14_g
+ N_X7_X1_X3_X1_14_X7_X1_X3_X1_M14_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M15 N_X7_X1_X3_X1_15_X7_X1_X3_X1_M15_d N_CLK_X7_X1_X3_X1_M15_g
+ N_VDD_X7_X1_X3_X1_M14_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M16 N_VDD_X7_X1_X3_X1_M16_d N_X7_X1_X3_X1_7_X7_X1_X3_X1_M16_g
+ N_X7_X1_X3_X1_10_X7_X1_X3_X1_M16_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M17 N_X7_X1_X3_X1_7_X7_X1_X3_X1_M17_d
+ N_X7_X1_X3_X1_10_X7_X1_X3_X1_M17_g N_VDD_X7_X1_X3_X1_M16_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M18 N_VDD_X7_X1_X3_X1_M18_d N_X7_X1_X3_X1_11_X7_X1_X3_X1_M18_g
+ N_X7_X1_37_X7_X1_X3_X1_M18_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_M19 N_X7_X1_X3_X1_11_X7_X1_X3_X1_M19_d N_X7_X1_37_X7_X1_X3_X1_M19_g
+ N_VDD_X7_X1_X3_X1_M18_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_X20_M0 N_X7_X1_X3_X1_16_X7_X1_X3_X1_X20_M0_d
+ N_X7_X1_X3_X1_X20_7_X7_X1_X3_X1_X20_M0_g N_X7_X1_37_X7_X1_X3_X1_X20_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_X20_M1 N_14_X7_X1_X3_X1_X20_M1_d N_X7_X1_29_X7_X1_X3_X1_X20_M1_g
+ N_X7_X1_X3_X1_16_X7_X1_X3_X1_X20_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_X20_M2 N_X7_X1_X3_X1_X20_7_X7_X1_X3_X1_X20_M2_d
+ N_X7_X1_29_X7_X1_X3_X1_X20_M2_g N_GROUND_X7_X1_X3_X1_X20_M2_s N_GROUND_X0_M0_b
+ NMOS L=1.3e-07 W=6e-07
mX7_X1_X3_X1_X20_M3 N_X7_X1_X3_X1_16_X7_X1_X3_X1_X20_M3_d
+ N_X7_X1_29_X7_X1_X3_X1_X20_M3_g N_X7_X1_37_X7_X1_X3_X1_X20_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X3_X1_X20_M4 N_14_X7_X1_X3_X1_X20_M4_d
+ N_X7_X1_X3_X1_X20_7_X7_X1_X3_X1_X20_M4_g N_X7_X1_X3_X1_16_X7_X1_X3_X1_X20_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X3_X1_X20_M5 N_X7_X1_X3_X1_X20_7_X7_X1_X3_X1_X20_M5_d
+ N_X7_X1_29_X7_X1_X3_X1_X20_M5_g N_VDD_X7_X1_X3_X1_X20_M5_s N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=1.35e-06
mX7_X1_X4_X0_M0 X7_X1_X4_X0_7 N_19_X7_X1_X4_X0_M0_g
+ N_X7_X1_X4_X0_6_X7_X1_X4_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX7_X1_X4_X0_M1 N_GROUND_X7_X1_X4_X0_M1_d N_34_X7_X1_X4_X0_M1_g X7_X1_X4_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX7_X1_X4_X0_M2 N_X7_X1_22_X7_X1_X4_X0_M2_d N_X7_X1_X4_X0_6_X7_X1_X4_X0_M2_g
+ N_GROUND_X7_X1_X4_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X4_X0_M3 N_X7_X1_X4_X0_6_X7_X1_X4_X0_M3_d N_19_X7_X1_X4_X0_M3_g
+ N_VDD_X7_X1_X4_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X4_X0_M4 N_VDD_X7_X1_X4_X0_M4_d N_34_X7_X1_X4_X0_M4_g
+ N_X7_X1_X4_X0_6_X7_X1_X4_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X4_X0_M5 N_X7_X1_22_X7_X1_X4_X0_M5_d N_X7_X1_X4_X0_6_X7_X1_X4_X0_M5_g
+ N_VDD_X7_X1_X4_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X4_X1_M0 X7_X1_X4_X1_7 N_20_X7_X1_X4_X1_M0_g
+ N_X7_X1_X4_X1_6_X7_X1_X4_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX7_X1_X4_X1_M1 N_GROUND_X7_X1_X4_X1_M1_d N_34_X7_X1_X4_X1_M1_g X7_X1_X4_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX7_X1_X4_X1_M2 N_X7_X1_23_X7_X1_X4_X1_M2_d N_X7_X1_X4_X1_6_X7_X1_X4_X1_M2_g
+ N_GROUND_X7_X1_X4_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X4_X1_M3 N_X7_X1_X4_X1_6_X7_X1_X4_X1_M3_d N_20_X7_X1_X4_X1_M3_g
+ N_VDD_X7_X1_X4_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X4_X1_M4 N_VDD_X7_X1_X4_X1_M4_d N_34_X7_X1_X4_X1_M4_g
+ N_X7_X1_X4_X1_6_X7_X1_X4_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X4_X1_M5 N_X7_X1_23_X7_X1_X4_X1_M5_d N_X7_X1_X4_X1_6_X7_X1_X4_X1_M5_g
+ N_VDD_X7_X1_X4_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X5_X0_M0 X7_X1_X5_X0_7 N_21_X7_X1_X5_X0_M0_g
+ N_X7_X1_X5_X0_6_X7_X1_X5_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX7_X1_X5_X0_M1 N_GROUND_X7_X1_X5_X0_M1_d N_34_X7_X1_X5_X0_M1_g X7_X1_X5_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX7_X1_X5_X0_M2 N_X7_X1_24_X7_X1_X5_X0_M2_d N_X7_X1_X5_X0_6_X7_X1_X5_X0_M2_g
+ N_GROUND_X7_X1_X5_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X5_X0_M3 N_X7_X1_X5_X0_6_X7_X1_X5_X0_M3_d N_21_X7_X1_X5_X0_M3_g
+ N_VDD_X7_X1_X5_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X5_X0_M4 N_VDD_X7_X1_X5_X0_M4_d N_34_X7_X1_X5_X0_M4_g
+ N_X7_X1_X5_X0_6_X7_X1_X5_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X5_X0_M5 N_X7_X1_24_X7_X1_X5_X0_M5_d N_X7_X1_X5_X0_6_X7_X1_X5_X0_M5_g
+ N_VDD_X7_X1_X5_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X5_X1_M0 X7_X1_X5_X1_7 N_22_X7_X1_X5_X1_M0_g
+ N_X7_X1_X5_X1_6_X7_X1_X5_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX7_X1_X5_X1_M1 N_GROUND_X7_X1_X5_X1_M1_d N_34_X7_X1_X5_X1_M1_g X7_X1_X5_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX7_X1_X5_X1_M2 N_X7_X1_25_X7_X1_X5_X1_M2_d N_X7_X1_X5_X1_6_X7_X1_X5_X1_M2_g
+ N_GROUND_X7_X1_X5_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X5_X1_M3 N_X7_X1_X5_X1_6_X7_X1_X5_X1_M3_d N_22_X7_X1_X5_X1_M3_g
+ N_VDD_X7_X1_X5_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X5_X1_M4 N_VDD_X7_X1_X5_X1_M4_d N_34_X7_X1_X5_X1_M4_g
+ N_X7_X1_X5_X1_6_X7_X1_X5_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X5_X1_M5 N_X7_X1_25_X7_X1_X5_X1_M5_d N_X7_X1_X5_X1_6_X7_X1_X5_X1_M5_g
+ N_VDD_X7_X1_X5_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X6_X0_M0 X7_X1_X6_X0_7 N_23_X7_X1_X6_X0_M0_g
+ N_X7_X1_X6_X0_6_X7_X1_X6_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX7_X1_X6_X0_M1 N_GROUND_X7_X1_X6_X0_M1_d N_34_X7_X1_X6_X0_M1_g X7_X1_X6_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX7_X1_X6_X0_M2 N_X7_X1_26_X7_X1_X6_X0_M2_d N_X7_X1_X6_X0_6_X7_X1_X6_X0_M2_g
+ N_GROUND_X7_X1_X6_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X6_X0_M3 N_X7_X1_X6_X0_6_X7_X1_X6_X0_M3_d N_23_X7_X1_X6_X0_M3_g
+ N_VDD_X7_X1_X6_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X6_X0_M4 N_VDD_X7_X1_X6_X0_M4_d N_34_X7_X1_X6_X0_M4_g
+ N_X7_X1_X6_X0_6_X7_X1_X6_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X6_X0_M5 N_X7_X1_26_X7_X1_X6_X0_M5_d N_X7_X1_X6_X0_6_X7_X1_X6_X0_M5_g
+ N_VDD_X7_X1_X6_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X6_X1_M0 X7_X1_X6_X1_7 N_24_X7_X1_X6_X1_M0_g
+ N_X7_X1_X6_X1_6_X7_X1_X6_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX7_X1_X6_X1_M1 N_GROUND_X7_X1_X6_X1_M1_d N_34_X7_X1_X6_X1_M1_g X7_X1_X6_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX7_X1_X6_X1_M2 N_X7_X1_27_X7_X1_X6_X1_M2_d N_X7_X1_X6_X1_6_X7_X1_X6_X1_M2_g
+ N_GROUND_X7_X1_X6_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X6_X1_M3 N_X7_X1_X6_X1_6_X7_X1_X6_X1_M3_d N_24_X7_X1_X6_X1_M3_g
+ N_VDD_X7_X1_X6_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X6_X1_M4 N_VDD_X7_X1_X6_X1_M4_d N_34_X7_X1_X6_X1_M4_g
+ N_X7_X1_X6_X1_6_X7_X1_X6_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X6_X1_M5 N_X7_X1_27_X7_X1_X6_X1_M5_d N_X7_X1_X6_X1_6_X7_X1_X6_X1_M5_g
+ N_VDD_X7_X1_X6_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X7_X0_M0 X7_X1_X7_X0_7 N_25_X7_X1_X7_X0_M0_g
+ N_X7_X1_X7_X0_6_X7_X1_X7_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX7_X1_X7_X0_M1 N_GROUND_X7_X1_X7_X0_M1_d N_34_X7_X1_X7_X0_M1_g X7_X1_X7_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX7_X1_X7_X0_M2 N_X7_X1_28_X7_X1_X7_X0_M2_d N_X7_X1_X7_X0_6_X7_X1_X7_X0_M2_g
+ N_GROUND_X7_X1_X7_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X7_X0_M3 N_X7_X1_X7_X0_6_X7_X1_X7_X0_M3_d N_25_X7_X1_X7_X0_M3_g
+ N_VDD_X7_X1_X7_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X7_X0_M4 N_VDD_X7_X1_X7_X0_M4_d N_34_X7_X1_X7_X0_M4_g
+ N_X7_X1_X7_X0_6_X7_X1_X7_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X7_X0_M5 N_X7_X1_28_X7_X1_X7_X0_M5_d N_X7_X1_X7_X0_6_X7_X1_X7_X0_M5_g
+ N_VDD_X7_X1_X7_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X7_X1_M0 X7_X1_X7_X1_7 N_26_X7_X1_X7_X1_M0_g
+ N_X7_X1_X7_X1_6_X7_X1_X7_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX7_X1_X7_X1_M1 N_GROUND_X7_X1_X7_X1_M1_d N_34_X7_X1_X7_X1_M1_g X7_X1_X7_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX7_X1_X7_X1_M2 N_X7_X1_29_X7_X1_X7_X1_M2_d N_X7_X1_X7_X1_6_X7_X1_X7_X1_M2_g
+ N_GROUND_X7_X1_X7_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X7_X1_M3 N_X7_X1_X7_X1_6_X7_X1_X7_X1_M3_d N_26_X7_X1_X7_X1_M3_g
+ N_VDD_X7_X1_X7_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X7_X1_M4 N_VDD_X7_X1_X7_X1_M4_d N_34_X7_X1_X7_X1_M4_g
+ N_X7_X1_X7_X1_6_X7_X1_X7_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X7_X1_M5 N_X7_X1_29_X7_X1_X7_X1_M5_d N_X7_X1_X7_X1_6_X7_X1_X7_X1_M5_g
+ N_VDD_X7_X1_X7_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X0_M0 N_X7_X1_X8_15_X7_X1_X8_X0_M0_d N_X7_X1_X8_X0_7_X7_X1_X8_X0_M0_g
+ N_X7_X1_30_X7_X1_X8_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X0_M1 N_X7_X1_31_X7_X1_X8_X0_M1_d N_RS0_X7_X1_X8_X0_M1_g
+ N_X7_X1_X8_15_X7_X1_X8_X0_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X0_M2 N_X7_X1_X8_X0_7_X7_X1_X8_X0_M2_d N_RS0_X7_X1_X8_X0_M2_g
+ N_GROUND_X7_X1_X8_X0_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X0_M3 N_X7_X1_X8_15_X7_X1_X8_X0_M3_d N_RS0_X7_X1_X8_X0_M3_g
+ N_X7_X1_30_X7_X1_X8_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X0_M4 N_X7_X1_31_X7_X1_X8_X0_M4_d N_X7_X1_X8_X0_7_X7_X1_X8_X0_M4_g
+ N_X7_X1_X8_15_X7_X1_X8_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X0_M5 N_X7_X1_X8_X0_7_X7_X1_X8_X0_M5_d N_RS0_X7_X1_X8_X0_M5_g
+ N_VDD_X7_X1_X8_X0_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X1_M0 N_X7_X1_X8_16_X7_X1_X8_X1_M0_d N_X7_X1_X8_X1_7_X7_X1_X8_X1_M0_g
+ N_X7_X1_32_X7_X1_X8_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X1_M1 N_X7_X1_33_X7_X1_X8_X1_M1_d N_RS0_X7_X1_X8_X1_M1_g
+ N_X7_X1_X8_16_X7_X1_X8_X1_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X1_M2 N_X7_X1_X8_X1_7_X7_X1_X8_X1_M2_d N_RS0_X7_X1_X8_X1_M2_g
+ N_GROUND_X7_X1_X8_X1_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X1_M3 N_X7_X1_X8_16_X7_X1_X8_X1_M3_d N_RS0_X7_X1_X8_X1_M3_g
+ N_X7_X1_32_X7_X1_X8_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X1_M4 N_X7_X1_33_X7_X1_X8_X1_M4_d N_X7_X1_X8_X1_7_X7_X1_X8_X1_M4_g
+ N_X7_X1_X8_16_X7_X1_X8_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X1_M5 N_X7_X1_X8_X1_7_X7_X1_X8_X1_M5_d N_RS0_X7_X1_X8_X1_M5_g
+ N_VDD_X7_X1_X8_X1_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X2_M0 N_X7_X1_X8_19_X7_X1_X8_X2_M0_d N_X7_X1_X8_X2_7_X7_X1_X8_X2_M0_g
+ N_X7_X1_X8_15_X7_X1_X8_X2_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X2_M1 N_X7_X1_X8_16_X7_X1_X8_X2_M1_d N_RS1_X7_X1_X8_X2_M1_g
+ N_X7_X1_X8_19_X7_X1_X8_X2_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X2_M2 N_X7_X1_X8_X2_7_X7_X1_X8_X2_M2_d N_RS1_X7_X1_X8_X2_M2_g
+ N_GROUND_X7_X1_X8_X2_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X2_M3 N_X7_X1_X8_19_X7_X1_X8_X2_M3_d N_RS1_X7_X1_X8_X2_M3_g
+ N_X7_X1_X8_15_X7_X1_X8_X2_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X2_M4 N_X7_X1_X8_16_X7_X1_X8_X2_M4_d N_X7_X1_X8_X2_7_X7_X1_X8_X2_M4_g
+ N_X7_X1_X8_19_X7_X1_X8_X2_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X2_M5 N_X7_X1_X8_X2_7_X7_X1_X8_X2_M5_d N_RS1_X7_X1_X8_X2_M5_g
+ N_VDD_X7_X1_X8_X2_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X3_M0 N_X7_X1_X8_17_X7_X1_X8_X3_M0_d N_X7_X1_X8_X3_7_X7_X1_X8_X3_M0_g
+ N_X7_X1_34_X7_X1_X8_X3_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X3_M1 N_X7_X1_35_X7_X1_X8_X3_M1_d N_RS0_X7_X1_X8_X3_M1_g
+ N_X7_X1_X8_17_X7_X1_X8_X3_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X3_M2 N_X7_X1_X8_X3_7_X7_X1_X8_X3_M2_d N_RS0_X7_X1_X8_X3_M2_g
+ N_GROUND_X7_X1_X8_X3_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X3_M3 N_X7_X1_X8_17_X7_X1_X8_X3_M3_d N_RS0_X7_X1_X8_X3_M3_g
+ N_X7_X1_34_X7_X1_X8_X3_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X3_M4 N_X7_X1_35_X7_X1_X8_X3_M4_d N_X7_X1_X8_X3_7_X7_X1_X8_X3_M4_g
+ N_X7_X1_X8_17_X7_X1_X8_X3_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X3_M5 N_X7_X1_X8_X3_7_X7_X1_X8_X3_M5_d N_RS0_X7_X1_X8_X3_M5_g
+ N_VDD_X7_X1_X8_X3_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X4_M0 N_X7_X1_X8_18_X7_X1_X8_X4_M0_d N_X7_X1_X8_X4_7_X7_X1_X8_X4_M0_g
+ N_X7_X1_36_X7_X1_X8_X4_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X4_M1 N_X7_X1_37_X7_X1_X8_X4_M1_d N_RS0_X7_X1_X8_X4_M1_g
+ N_X7_X1_X8_18_X7_X1_X8_X4_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X4_M2 N_X7_X1_X8_X4_7_X7_X1_X8_X4_M2_d N_RS0_X7_X1_X8_X4_M2_g
+ N_GROUND_X7_X1_X8_X4_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X4_M3 N_X7_X1_X8_18_X7_X1_X8_X4_M3_d N_RS0_X7_X1_X8_X4_M3_g
+ N_X7_X1_36_X7_X1_X8_X4_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X4_M4 N_X7_X1_37_X7_X1_X8_X4_M4_d N_X7_X1_X8_X4_7_X7_X1_X8_X4_M4_g
+ N_X7_X1_X8_18_X7_X1_X8_X4_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X4_M5 N_X7_X1_X8_X4_7_X7_X1_X8_X4_M5_d N_RS0_X7_X1_X8_X4_M5_g
+ N_VDD_X7_X1_X8_X4_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X5_M0 N_X7_X1_X8_20_X7_X1_X8_X5_M0_d N_X7_X1_X8_X5_7_X7_X1_X8_X5_M0_g
+ N_X7_X1_X8_17_X7_X1_X8_X5_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X5_M1 N_X7_X1_X8_18_X7_X1_X8_X5_M1_d N_RS1_X7_X1_X8_X5_M1_g
+ N_X7_X1_X8_20_X7_X1_X8_X5_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X5_M2 N_X7_X1_X8_X5_7_X7_X1_X8_X5_M2_d N_RS1_X7_X1_X8_X5_M2_g
+ N_GROUND_X7_X1_X8_X5_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X5_M3 N_X7_X1_X8_20_X7_X1_X8_X5_M3_d N_RS1_X7_X1_X8_X5_M3_g
+ N_X7_X1_X8_17_X7_X1_X8_X5_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X5_M4 N_X7_X1_X8_18_X7_X1_X8_X5_M4_d N_X7_X1_X8_X5_7_X7_X1_X8_X5_M4_g
+ N_X7_X1_X8_20_X7_X1_X8_X5_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X5_M5 N_X7_X1_X8_X5_7_X7_X1_X8_X5_M5_d N_RS1_X7_X1_X8_X5_M5_g
+ N_VDD_X7_X1_X8_X5_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X6_M0 N_X7_47_X7_X1_X8_X6_M0_d N_X7_X1_X8_X6_7_X7_X1_X8_X6_M0_g
+ N_X7_X1_X8_19_X7_X1_X8_X6_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X6_M1 N_X7_X1_X8_20_X7_X1_X8_X6_M1_d N_RS2_X7_X1_X8_X6_M1_g
+ N_X7_47_X7_X1_X8_X6_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X6_M2 N_X7_X1_X8_X6_7_X7_X1_X8_X6_M2_d N_RS2_X7_X1_X8_X6_M2_g
+ N_GROUND_X7_X1_X8_X6_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X8_X6_M3 N_X7_47_X7_X1_X8_X6_M3_d N_RS2_X7_X1_X8_X6_M3_g
+ N_X7_X1_X8_19_X7_X1_X8_X6_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X6_M4 N_X7_X1_X8_20_X7_X1_X8_X6_M4_d N_X7_X1_X8_X6_7_X7_X1_X8_X6_M4_g
+ N_X7_47_X7_X1_X8_X6_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X8_X6_M5 N_X7_X1_X8_X6_7_X7_X1_X8_X6_M5_d N_RS2_X7_X1_X8_X6_M5_g
+ N_VDD_X7_X1_X8_X6_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X0_M0 N_X7_X1_X9_15_X7_X1_X9_X0_M0_d N_X7_X1_X9_X0_7_X7_X1_X9_X0_M0_g
+ N_X7_X1_30_X7_X1_X9_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X0_M1 N_X7_X1_31_X7_X1_X9_X0_M1_d N_RT0_X7_X1_X9_X0_M1_g
+ N_X7_X1_X9_15_X7_X1_X9_X0_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X0_M2 N_X7_X1_X9_X0_7_X7_X1_X9_X0_M2_d N_RT0_X7_X1_X9_X0_M2_g
+ N_GROUND_X7_X1_X9_X0_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X0_M3 N_X7_X1_X9_15_X7_X1_X9_X0_M3_d N_RT0_X7_X1_X9_X0_M3_g
+ N_X7_X1_30_X7_X1_X9_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X0_M4 N_X7_X1_31_X7_X1_X9_X0_M4_d N_X7_X1_X9_X0_7_X7_X1_X9_X0_M4_g
+ N_X7_X1_X9_15_X7_X1_X9_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X0_M5 N_X7_X1_X9_X0_7_X7_X1_X9_X0_M5_d N_RT0_X7_X1_X9_X0_M5_g
+ N_VDD_X7_X1_X9_X0_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X1_M0 N_X7_X1_X9_16_X7_X1_X9_X1_M0_d N_X7_X1_X9_X1_7_X7_X1_X9_X1_M0_g
+ N_X7_X1_32_X7_X1_X9_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X1_M1 N_X7_X1_33_X7_X1_X9_X1_M1_d N_RT0_X7_X1_X9_X1_M1_g
+ N_X7_X1_X9_16_X7_X1_X9_X1_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X1_M2 N_X7_X1_X9_X1_7_X7_X1_X9_X1_M2_d N_RT0_X7_X1_X9_X1_M2_g
+ N_GROUND_X7_X1_X9_X1_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X1_M3 N_X7_X1_X9_16_X7_X1_X9_X1_M3_d N_RT0_X7_X1_X9_X1_M3_g
+ N_X7_X1_32_X7_X1_X9_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X1_M4 N_X7_X1_33_X7_X1_X9_X1_M4_d N_X7_X1_X9_X1_7_X7_X1_X9_X1_M4_g
+ N_X7_X1_X9_16_X7_X1_X9_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X1_M5 N_X7_X1_X9_X1_7_X7_X1_X9_X1_M5_d N_RT0_X7_X1_X9_X1_M5_g
+ N_VDD_X7_X1_X9_X1_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X2_M0 N_X7_X1_X9_19_X7_X1_X9_X2_M0_d N_X7_X1_X9_X2_7_X7_X1_X9_X2_M0_g
+ N_X7_X1_X9_15_X7_X1_X9_X2_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X2_M1 N_X7_X1_X9_16_X7_X1_X9_X2_M1_d N_RT1_X7_X1_X9_X2_M1_g
+ N_X7_X1_X9_19_X7_X1_X9_X2_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X2_M2 N_X7_X1_X9_X2_7_X7_X1_X9_X2_M2_d N_RT1_X7_X1_X9_X2_M2_g
+ N_GROUND_X7_X1_X9_X2_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X2_M3 N_X7_X1_X9_19_X7_X1_X9_X2_M3_d N_RT1_X7_X1_X9_X2_M3_g
+ N_X7_X1_X9_15_X7_X1_X9_X2_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X2_M4 N_X7_X1_X9_16_X7_X1_X9_X2_M4_d N_X7_X1_X9_X2_7_X7_X1_X9_X2_M4_g
+ N_X7_X1_X9_19_X7_X1_X9_X2_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X2_M5 N_X7_X1_X9_X2_7_X7_X1_X9_X2_M5_d N_RT1_X7_X1_X9_X2_M5_g
+ N_VDD_X7_X1_X9_X2_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X3_M0 N_X7_X1_X9_17_X7_X1_X9_X3_M0_d N_X7_X1_X9_X3_7_X7_X1_X9_X3_M0_g
+ N_X7_X1_34_X7_X1_X9_X3_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X3_M1 N_X7_X1_35_X7_X1_X9_X3_M1_d N_RT0_X7_X1_X9_X3_M1_g
+ N_X7_X1_X9_17_X7_X1_X9_X3_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X3_M2 N_X7_X1_X9_X3_7_X7_X1_X9_X3_M2_d N_RT0_X7_X1_X9_X3_M2_g
+ N_GROUND_X7_X1_X9_X3_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X3_M3 N_X7_X1_X9_17_X7_X1_X9_X3_M3_d N_RT0_X7_X1_X9_X3_M3_g
+ N_X7_X1_34_X7_X1_X9_X3_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X3_M4 N_X7_X1_35_X7_X1_X9_X3_M4_d N_X7_X1_X9_X3_7_X7_X1_X9_X3_M4_g
+ N_X7_X1_X9_17_X7_X1_X9_X3_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X3_M5 N_X7_X1_X9_X3_7_X7_X1_X9_X3_M5_d N_RT0_X7_X1_X9_X3_M5_g
+ N_VDD_X7_X1_X9_X3_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X4_M0 N_X7_X1_X9_18_X7_X1_X9_X4_M0_d N_X7_X1_X9_X4_7_X7_X1_X9_X4_M0_g
+ N_X7_X1_36_X7_X1_X9_X4_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X4_M1 N_X7_X1_37_X7_X1_X9_X4_M1_d N_RT0_X7_X1_X9_X4_M1_g
+ N_X7_X1_X9_18_X7_X1_X9_X4_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X4_M2 N_X7_X1_X9_X4_7_X7_X1_X9_X4_M2_d N_RT0_X7_X1_X9_X4_M2_g
+ N_GROUND_X7_X1_X9_X4_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X4_M3 N_X7_X1_X9_18_X7_X1_X9_X4_M3_d N_RT0_X7_X1_X9_X4_M3_g
+ N_X7_X1_36_X7_X1_X9_X4_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X4_M4 N_X7_X1_37_X7_X1_X9_X4_M4_d N_X7_X1_X9_X4_7_X7_X1_X9_X4_M4_g
+ N_X7_X1_X9_18_X7_X1_X9_X4_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X4_M5 N_X7_X1_X9_X4_7_X7_X1_X9_X4_M5_d N_RT0_X7_X1_X9_X4_M5_g
+ N_VDD_X7_X1_X9_X4_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X5_M0 N_X7_X1_X9_20_X7_X1_X9_X5_M0_d N_X7_X1_X9_X5_7_X7_X1_X9_X5_M0_g
+ N_X7_X1_X9_17_X7_X1_X9_X5_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X5_M1 N_X7_X1_X9_18_X7_X1_X9_X5_M1_d N_RT1_X7_X1_X9_X5_M1_g
+ N_X7_X1_X9_20_X7_X1_X9_X5_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X5_M2 N_X7_X1_X9_X5_7_X7_X1_X9_X5_M2_d N_RT1_X7_X1_X9_X5_M2_g
+ N_GROUND_X7_X1_X9_X5_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X5_M3 N_X7_X1_X9_20_X7_X1_X9_X5_M3_d N_RT1_X7_X1_X9_X5_M3_g
+ N_X7_X1_X9_17_X7_X1_X9_X5_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X5_M4 N_X7_X1_X9_18_X7_X1_X9_X5_M4_d N_X7_X1_X9_X5_7_X7_X1_X9_X5_M4_g
+ N_X7_X1_X9_20_X7_X1_X9_X5_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X5_M5 N_X7_X1_X9_X5_7_X7_X1_X9_X5_M5_d N_RT1_X7_X1_X9_X5_M5_g
+ N_VDD_X7_X1_X9_X5_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X6_M0 N_X7_48_X7_X1_X9_X6_M0_d N_X7_X1_X9_X6_7_X7_X1_X9_X6_M0_g
+ N_X7_X1_X9_19_X7_X1_X9_X6_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X6_M1 N_X7_X1_X9_20_X7_X1_X9_X6_M1_d N_RT2_X7_X1_X9_X6_M1_g
+ N_X7_48_X7_X1_X9_X6_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X6_M2 N_X7_X1_X9_X6_7_X7_X1_X9_X6_M2_d N_RT2_X7_X1_X9_X6_M2_g
+ N_GROUND_X7_X1_X9_X6_M2_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX7_X1_X9_X6_M3 N_X7_48_X7_X1_X9_X6_M3_d N_RT2_X7_X1_X9_X6_M3_g
+ N_X7_X1_X9_19_X7_X1_X9_X6_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X6_M4 N_X7_X1_X9_20_X7_X1_X9_X6_M4_d N_X7_X1_X9_X6_7_X7_X1_X9_X6_M4_g
+ N_X7_48_X7_X1_X9_X6_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX7_X1_X9_X6_M5 N_X7_X1_X9_X6_7_X7_X1_X9_X6_M5_d N_RT2_X7_X1_X9_X6_M5_g
+ N_VDD_X7_X1_X9_X6_M5_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X0_M0 N_X8_16_X8_X0_M0_d N_RD2_X8_X0_M0_g N_GROUND_X8_X0_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X0_M1 N_X8_16_X8_X0_M1_d N_RD2_X8_X0_M1_g N_VDD_X8_X0_M1_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX8_X1_M0 N_X8_14_X8_X1_M0_d N_RD0_X8_X1_M0_g N_GROUND_X8_X1_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X1_M1 N_X8_14_X8_X1_M1_d N_RD0_X8_X1_M1_g N_VDD_X8_X1_M1_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX8_X2_M0 N_X8_15_X8_X2_M0_d N_RD1_X8_X2_M0_g N_GROUND_X8_X2_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X2_M1 N_X8_15_X8_X2_M1_d N_RD1_X8_X2_M1_g N_VDD_X8_X2_M1_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX8_X3_X0_M0 X8_X3_X0_7 N_X8_14_X8_X3_X0_M0_g N_X8_X3_X0_6_X8_X3_X0_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X3_X0_M1 N_GROUND_X8_X3_X0_M1_d N_X8_15_X8_X3_X0_M1_g X8_X3_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X3_X0_M2 N_X8_X3_7_X8_X3_X0_M2_d N_X8_X3_X0_6_X8_X3_X0_M2_g
+ N_GROUND_X8_X3_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X3_X0_M3 N_X8_X3_X0_6_X8_X3_X0_M3_d N_X8_14_X8_X3_X0_M3_g
+ N_VDD_X8_X3_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X3_X0_M4 N_VDD_X8_X3_X0_M4_d N_X8_15_X8_X3_X0_M4_g
+ N_X8_X3_X0_6_X8_X3_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X3_X0_M5 N_X8_X3_7_X8_X3_X0_M5_d N_X8_X3_X0_6_X8_X3_X0_M5_g
+ N_VDD_X8_X3_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X3_X1_M0 X8_X3_X1_7 N_X8_X3_7_X8_X3_X1_M0_g N_X8_X3_X1_6_X8_X3_X1_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X3_X1_M1 N_GROUND_X8_X3_X1_M1_d N_X8_16_X8_X3_X1_M1_g X8_X3_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X3_X1_M2 N_19_X8_X3_X1_M2_d N_X8_X3_X1_6_X8_X3_X1_M2_g
+ N_GROUND_X8_X3_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X3_X1_M3 N_X8_X3_X1_6_X8_X3_X1_M3_d N_X8_X3_7_X8_X3_X1_M3_g
+ N_VDD_X8_X3_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X3_X1_M4 N_VDD_X8_X3_X1_M4_d N_X8_16_X8_X3_X1_M4_g
+ N_X8_X3_X1_6_X8_X3_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X3_X1_M5 N_19_X8_X3_X1_M5_d N_X8_X3_X1_6_X8_X3_X1_M5_g N_VDD_X8_X3_X1_M4_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X4_X0_M0 X8_X4_X0_7 N_RD0_X8_X4_X0_M0_g N_X8_X4_X0_6_X8_X4_X0_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X4_X0_M1 N_GROUND_X8_X4_X0_M1_d N_X8_15_X8_X4_X0_M1_g X8_X4_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X4_X0_M2 N_X8_X4_7_X8_X4_X0_M2_d N_X8_X4_X0_6_X8_X4_X0_M2_g
+ N_GROUND_X8_X4_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X4_X0_M3 N_X8_X4_X0_6_X8_X4_X0_M3_d N_RD0_X8_X4_X0_M3_g N_VDD_X8_X4_X0_M3_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X4_X0_M4 N_VDD_X8_X4_X0_M4_d N_X8_15_X8_X4_X0_M4_g
+ N_X8_X4_X0_6_X8_X4_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X4_X0_M5 N_X8_X4_7_X8_X4_X0_M5_d N_X8_X4_X0_6_X8_X4_X0_M5_g
+ N_VDD_X8_X4_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X4_X1_M0 X8_X4_X1_7 N_X8_X4_7_X8_X4_X1_M0_g N_X8_X4_X1_6_X8_X4_X1_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X4_X1_M1 N_GROUND_X8_X4_X1_M1_d N_X8_16_X8_X4_X1_M1_g X8_X4_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X4_X1_M2 N_20_X8_X4_X1_M2_d N_X8_X4_X1_6_X8_X4_X1_M2_g
+ N_GROUND_X8_X4_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X4_X1_M3 N_X8_X4_X1_6_X8_X4_X1_M3_d N_X8_X4_7_X8_X4_X1_M3_g
+ N_VDD_X8_X4_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X4_X1_M4 N_VDD_X8_X4_X1_M4_d N_X8_16_X8_X4_X1_M4_g
+ N_X8_X4_X1_6_X8_X4_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X4_X1_M5 N_20_X8_X4_X1_M5_d N_X8_X4_X1_6_X8_X4_X1_M5_g N_VDD_X8_X4_X1_M4_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X5_X0_M0 X8_X5_X0_7 N_X8_14_X8_X5_X0_M0_g N_X8_X5_X0_6_X8_X5_X0_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X5_X0_M1 N_GROUND_X8_X5_X0_M1_d N_RD1_X8_X5_X0_M1_g X8_X5_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X5_X0_M2 N_X8_X5_7_X8_X5_X0_M2_d N_X8_X5_X0_6_X8_X5_X0_M2_g
+ N_GROUND_X8_X5_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X5_X0_M3 N_X8_X5_X0_6_X8_X5_X0_M3_d N_X8_14_X8_X5_X0_M3_g
+ N_VDD_X8_X5_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X5_X0_M4 N_VDD_X8_X5_X0_M4_d N_RD1_X8_X5_X0_M4_g N_X8_X5_X0_6_X8_X5_X0_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X5_X0_M5 N_X8_X5_7_X8_X5_X0_M5_d N_X8_X5_X0_6_X8_X5_X0_M5_g
+ N_VDD_X8_X5_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X5_X1_M0 X8_X5_X1_7 N_X8_X5_7_X8_X5_X1_M0_g N_X8_X5_X1_6_X8_X5_X1_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X5_X1_M1 N_GROUND_X8_X5_X1_M1_d N_X8_16_X8_X5_X1_M1_g X8_X5_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X5_X1_M2 N_21_X8_X5_X1_M2_d N_X8_X5_X1_6_X8_X5_X1_M2_g
+ N_GROUND_X8_X5_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X5_X1_M3 N_X8_X5_X1_6_X8_X5_X1_M3_d N_X8_X5_7_X8_X5_X1_M3_g
+ N_VDD_X8_X5_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X5_X1_M4 N_VDD_X8_X5_X1_M4_d N_X8_16_X8_X5_X1_M4_g
+ N_X8_X5_X1_6_X8_X5_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X5_X1_M5 N_21_X8_X5_X1_M5_d N_X8_X5_X1_6_X8_X5_X1_M5_g N_VDD_X8_X5_X1_M4_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X6_X0_M0 X8_X6_X0_7 N_RD0_X8_X6_X0_M0_g N_X8_X6_X0_6_X8_X6_X0_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X6_X0_M1 N_GROUND_X8_X6_X0_M1_d N_RD1_X8_X6_X0_M1_g X8_X6_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X6_X0_M2 N_X8_X6_7_X8_X6_X0_M2_d N_X8_X6_X0_6_X8_X6_X0_M2_g
+ N_GROUND_X8_X6_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X6_X0_M3 N_X8_X6_X0_6_X8_X6_X0_M3_d N_RD0_X8_X6_X0_M3_g N_VDD_X8_X6_X0_M3_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X6_X0_M4 N_VDD_X8_X6_X0_M4_d N_RD1_X8_X6_X0_M4_g N_X8_X6_X0_6_X8_X6_X0_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X6_X0_M5 N_X8_X6_7_X8_X6_X0_M5_d N_X8_X6_X0_6_X8_X6_X0_M5_g
+ N_VDD_X8_X6_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X6_X1_M0 X8_X6_X1_7 N_X8_X6_7_X8_X6_X1_M0_g N_X8_X6_X1_6_X8_X6_X1_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X6_X1_M1 N_GROUND_X8_X6_X1_M1_d N_X8_16_X8_X6_X1_M1_g X8_X6_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X6_X1_M2 N_22_X8_X6_X1_M2_d N_X8_X6_X1_6_X8_X6_X1_M2_g
+ N_GROUND_X8_X6_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X6_X1_M3 N_X8_X6_X1_6_X8_X6_X1_M3_d N_X8_X6_7_X8_X6_X1_M3_g
+ N_VDD_X8_X6_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X6_X1_M4 N_VDD_X8_X6_X1_M4_d N_X8_16_X8_X6_X1_M4_g
+ N_X8_X6_X1_6_X8_X6_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X6_X1_M5 N_22_X8_X6_X1_M5_d N_X8_X6_X1_6_X8_X6_X1_M5_g N_VDD_X8_X6_X1_M4_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X7_X0_M0 X8_X7_X0_7 N_X8_14_X8_X7_X0_M0_g N_X8_X7_X0_6_X8_X7_X0_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X7_X0_M1 N_GROUND_X8_X7_X0_M1_d N_X8_15_X8_X7_X0_M1_g X8_X7_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X7_X0_M2 N_X8_X7_7_X8_X7_X0_M2_d N_X8_X7_X0_6_X8_X7_X0_M2_g
+ N_GROUND_X8_X7_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X7_X0_M3 N_X8_X7_X0_6_X8_X7_X0_M3_d N_X8_14_X8_X7_X0_M3_g
+ N_VDD_X8_X7_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X7_X0_M4 N_VDD_X8_X7_X0_M4_d N_X8_15_X8_X7_X0_M4_g
+ N_X8_X7_X0_6_X8_X7_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X7_X0_M5 N_X8_X7_7_X8_X7_X0_M5_d N_X8_X7_X0_6_X8_X7_X0_M5_g
+ N_VDD_X8_X7_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X7_X1_M0 X8_X7_X1_7 N_X8_X7_7_X8_X7_X1_M0_g N_X8_X7_X1_6_X8_X7_X1_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X7_X1_M1 N_GROUND_X8_X7_X1_M1_d N_RD2_X8_X7_X1_M1_g X8_X7_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X7_X1_M2 N_23_X8_X7_X1_M2_d N_X8_X7_X1_6_X8_X7_X1_M2_g
+ N_GROUND_X8_X7_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X7_X1_M3 N_X8_X7_X1_6_X8_X7_X1_M3_d N_X8_X7_7_X8_X7_X1_M3_g
+ N_VDD_X8_X7_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X7_X1_M4 N_VDD_X8_X7_X1_M4_d N_RD2_X8_X7_X1_M4_g N_X8_X7_X1_6_X8_X7_X1_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X7_X1_M5 N_23_X8_X7_X1_M5_d N_X8_X7_X1_6_X8_X7_X1_M5_g N_VDD_X8_X7_X1_M4_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X8_X0_M0 X8_X8_X0_7 N_RD0_X8_X8_X0_M0_g N_X8_X8_X0_6_X8_X8_X0_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X8_X0_M1 N_GROUND_X8_X8_X0_M1_d N_X8_15_X8_X8_X0_M1_g X8_X8_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X8_X0_M2 N_X8_X8_7_X8_X8_X0_M2_d N_X8_X8_X0_6_X8_X8_X0_M2_g
+ N_GROUND_X8_X8_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X8_X0_M3 N_X8_X8_X0_6_X8_X8_X0_M3_d N_RD0_X8_X8_X0_M3_g N_VDD_X8_X8_X0_M3_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X8_X0_M4 N_VDD_X8_X8_X0_M4_d N_X8_15_X8_X8_X0_M4_g
+ N_X8_X8_X0_6_X8_X8_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X8_X0_M5 N_X8_X8_7_X8_X8_X0_M5_d N_X8_X8_X0_6_X8_X8_X0_M5_g
+ N_VDD_X8_X8_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X8_X1_M0 X8_X8_X1_7 N_X8_X8_7_X8_X8_X1_M0_g N_X8_X8_X1_6_X8_X8_X1_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X8_X1_M1 N_GROUND_X8_X8_X1_M1_d N_RD2_X8_X8_X1_M1_g X8_X8_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X8_X1_M2 N_24_X8_X8_X1_M2_d N_X8_X8_X1_6_X8_X8_X1_M2_g
+ N_GROUND_X8_X8_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X8_X1_M3 N_X8_X8_X1_6_X8_X8_X1_M3_d N_X8_X8_7_X8_X8_X1_M3_g
+ N_VDD_X8_X8_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X8_X1_M4 N_VDD_X8_X8_X1_M4_d N_RD2_X8_X8_X1_M4_g N_X8_X8_X1_6_X8_X8_X1_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X8_X1_M5 N_24_X8_X8_X1_M5_d N_X8_X8_X1_6_X8_X8_X1_M5_g N_VDD_X8_X8_X1_M4_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X9_X0_M0 X8_X9_X0_7 N_X8_14_X8_X9_X0_M0_g N_X8_X9_X0_6_X8_X9_X0_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X9_X0_M1 N_GROUND_X8_X9_X0_M1_d N_RD1_X8_X9_X0_M1_g X8_X9_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X9_X0_M2 N_X8_X9_7_X8_X9_X0_M2_d N_X8_X9_X0_6_X8_X9_X0_M2_g
+ N_GROUND_X8_X9_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X9_X0_M3 N_X8_X9_X0_6_X8_X9_X0_M3_d N_X8_14_X8_X9_X0_M3_g
+ N_VDD_X8_X9_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X9_X0_M4 N_VDD_X8_X9_X0_M4_d N_RD1_X8_X9_X0_M4_g N_X8_X9_X0_6_X8_X9_X0_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X9_X0_M5 N_X8_X9_7_X8_X9_X0_M5_d N_X8_X9_X0_6_X8_X9_X0_M5_g
+ N_VDD_X8_X9_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X9_X1_M0 X8_X9_X1_7 N_X8_X9_7_X8_X9_X1_M0_g N_X8_X9_X1_6_X8_X9_X1_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X9_X1_M1 N_GROUND_X8_X9_X1_M1_d N_RD2_X8_X9_X1_M1_g X8_X9_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X9_X1_M2 N_25_X8_X9_X1_M2_d N_X8_X9_X1_6_X8_X9_X1_M2_g
+ N_GROUND_X8_X9_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X9_X1_M3 N_X8_X9_X1_6_X8_X9_X1_M3_d N_X8_X9_7_X8_X9_X1_M3_g
+ N_VDD_X8_X9_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X9_X1_M4 N_VDD_X8_X9_X1_M4_d N_RD2_X8_X9_X1_M4_g N_X8_X9_X1_6_X8_X9_X1_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X9_X1_M5 N_25_X8_X9_X1_M5_d N_X8_X9_X1_6_X8_X9_X1_M5_g N_VDD_X8_X9_X1_M4_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X10_X0_M0 X8_X10_X0_7 N_RD0_X8_X10_X0_M0_g N_X8_X10_X0_6_X8_X10_X0_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X10_X0_M1 N_GROUND_X8_X10_X0_M1_d N_RD1_X8_X10_X0_M1_g X8_X10_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X10_X0_M2 N_X8_X10_7_X8_X10_X0_M2_d N_X8_X10_X0_6_X8_X10_X0_M2_g
+ N_GROUND_X8_X10_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X10_X0_M3 N_X8_X10_X0_6_X8_X10_X0_M3_d N_RD0_X8_X10_X0_M3_g
+ N_VDD_X8_X10_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X10_X0_M4 N_VDD_X8_X10_X0_M4_d N_RD1_X8_X10_X0_M4_g
+ N_X8_X10_X0_6_X8_X10_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X10_X0_M5 N_X8_X10_7_X8_X10_X0_M5_d N_X8_X10_X0_6_X8_X10_X0_M5_g
+ N_VDD_X8_X10_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X10_X1_M0 X8_X10_X1_7 N_X8_X10_7_X8_X10_X1_M0_g N_X8_X10_X1_6_X8_X10_X1_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X10_X1_M1 N_GROUND_X8_X10_X1_M1_d N_RD2_X8_X10_X1_M1_g X8_X10_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX8_X10_X1_M2 N_26_X8_X10_X1_M2_d N_X8_X10_X1_6_X8_X10_X1_M2_g
+ N_GROUND_X8_X10_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX8_X10_X1_M3 N_X8_X10_X1_6_X8_X10_X1_M3_d N_X8_X10_7_X8_X10_X1_M3_g
+ N_VDD_X8_X10_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X10_X1_M4 N_VDD_X8_X10_X1_M4_d N_RD2_X8_X10_X1_M4_g
+ N_X8_X10_X1_6_X8_X10_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX8_X10_X1_M5 N_26_X8_X10_X1_M5_d N_X8_X10_X1_6_X8_X10_X1_M5_g
+ N_VDD_X8_X10_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X0_M0 N_X9_X0_6_X9_X0_M0_d N_X9_24_X9_X0_M0_g N_GROUND_X9_X0_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X0_M1 N_GROUND_X9_X0_M1_d N_X9_25_X9_X0_M1_g N_X9_X0_6_X9_X0_M0_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X0_M2 N_34_X9_X0_M2_d N_X9_X0_6_X9_X0_M2_g N_GROUND_X9_X0_M1_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X0_M3 N_VDD_X9_X0_M3_d N_X9_X0_6_X9_X0_M3_g N_34_X9_X0_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX9_X0_M4 X9_X0_7 N_X9_25_X9_X0_M4_g N_VDD_X9_X0_M3_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=2.7e-06
mX9_X0_M5 N_X9_X0_6_X9_X0_M5_d N_X9_24_X9_X0_M5_g X9_X0_7 N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=2.7e-06
mX9_X1_M0 N_X9_X1_6_X9_X1_M0_d N_X9_24_X9_X1_M0_g N_GROUND_X9_X1_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X1_M1 N_GROUND_X9_X1_M1_d N_X9_28_X9_X1_M1_g N_X9_X1_6_X9_X1_M0_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X1_M2 N_30_X9_X1_M2_d N_X9_X1_6_X9_X1_M2_g N_GROUND_X9_X1_M1_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X1_M3 N_VDD_X9_X1_M3_d N_X9_X1_6_X9_X1_M3_g N_30_X9_X1_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX9_X1_M4 X9_X1_7 N_X9_28_X9_X1_M4_g N_VDD_X9_X1_M3_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=2.7e-06
mX9_X1_M5 N_X9_X1_6_X9_X1_M5_d N_X9_24_X9_X1_M5_g X9_X1_7 N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=2.7e-06
mX9_X2_M0 N_X9_X2_6_X9_X2_M0_d N_PCSRC_X9_X2_M0_g N_GROUND_X9_X2_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X2_M1 N_GROUND_X9_X2_M1_d N_X9_30_X9_X2_M1_g N_X9_X2_6_X9_X2_M0_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X2_M2 N_29_X9_X2_M2_d N_X9_X2_6_X9_X2_M2_g N_GROUND_X9_X2_M1_d
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X2_M3 N_VDD_X9_X2_M3_d N_X9_X2_6_X9_X2_M3_g N_29_X9_X2_M3_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX9_X2_M4 X9_X2_7 N_X9_30_X9_X2_M4_g N_VDD_X9_X2_M3_d N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=2.7e-06
mX9_X2_M5 N_X9_X2_6_X9_X2_M5_d N_PCSRC_X9_X2_M5_g X9_X2_7 N_VDD_X0_M3_b PMOS
+ L=1.3e-07 W=2.7e-06
mX9_X3_M0 N_X9_19_X9_X3_M0_d N_OP0_X9_X3_M0_g N_GROUND_X9_X3_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X3_M1 N_X9_19_X9_X3_M1_d N_OP0_X9_X3_M1_g N_VDD_X9_X3_M1_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX9_X4_M0 N_X9_20_X9_X4_M0_d N_OP1_X9_X4_M0_g N_GROUND_X9_X4_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X4_M1 N_X9_20_X9_X4_M1_d N_OP1_X9_X4_M1_g N_VDD_X9_X4_M1_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX9_X5_M0 N_X9_21_X9_X5_M0_d N_OP2_X9_X5_M0_g N_GROUND_X9_X5_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X5_M1 N_X9_21_X9_X5_M1_d N_OP2_X9_X5_M1_g N_VDD_X9_X5_M1_s N_VDD_X0_M3_b
+ PMOS L=1.3e-07 W=1.35e-06
mX9_X6_X0_M0 X9_X6_X0_7 N_X9_19_X9_X6_X0_M0_g N_X9_X6_X0_6_X9_X6_X0_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X6_X0_M1 N_GROUND_X9_X6_X0_M1_d N_X9_20_X9_X6_X0_M1_g X9_X6_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X6_X0_M2 N_X9_X6_7_X9_X6_X0_M2_d N_X9_X6_X0_6_X9_X6_X0_M2_g
+ N_GROUND_X9_X6_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X6_X0_M3 N_X9_X6_X0_6_X9_X6_X0_M3_d N_X9_19_X9_X6_X0_M3_g
+ N_VDD_X9_X6_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X6_X0_M4 N_VDD_X9_X6_X0_M4_d N_X9_20_X9_X6_X0_M4_g
+ N_X9_X6_X0_6_X9_X6_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X6_X0_M5 N_X9_X6_7_X9_X6_X0_M5_d N_X9_X6_X0_6_X9_X6_X0_M5_g
+ N_VDD_X9_X6_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X6_X1_M0 X9_X6_X1_7 N_X9_X6_7_X9_X6_X1_M0_g N_X9_X6_X1_6_X9_X6_X1_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X6_X1_M1 N_GROUND_X9_X6_X1_M1_d N_X9_21_X9_X6_X1_M1_g X9_X6_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X6_X1_M2 N_X9_22_X9_X6_X1_M2_d N_X9_X6_X1_6_X9_X6_X1_M2_g
+ N_GROUND_X9_X6_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X6_X1_M3 N_X9_X6_X1_6_X9_X6_X1_M3_d N_X9_X6_7_X9_X6_X1_M3_g
+ N_VDD_X9_X6_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X6_X1_M4 N_VDD_X9_X6_X1_M4_d N_X9_21_X9_X6_X1_M4_g
+ N_X9_X6_X1_6_X9_X6_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X6_X1_M5 N_X9_22_X9_X6_X1_M5_d N_X9_X6_X1_6_X9_X6_X1_M5_g
+ N_VDD_X9_X6_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X7_X0_M0 X9_X7_X0_7 N_OP0_X9_X7_X0_M0_g N_X9_X7_X0_6_X9_X7_X0_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X7_X0_M1 N_GROUND_X9_X7_X0_M1_d N_X9_20_X9_X7_X0_M1_g X9_X7_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X7_X0_M2 N_X9_X7_7_X9_X7_X0_M2_d N_X9_X7_X0_6_X9_X7_X0_M2_g
+ N_GROUND_X9_X7_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X7_X0_M3 N_X9_X7_X0_6_X9_X7_X0_M3_d N_OP0_X9_X7_X0_M3_g N_VDD_X9_X7_X0_M3_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X7_X0_M4 N_VDD_X9_X7_X0_M4_d N_X9_20_X9_X7_X0_M4_g
+ N_X9_X7_X0_6_X9_X7_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X7_X0_M5 N_X9_X7_7_X9_X7_X0_M5_d N_X9_X7_X0_6_X9_X7_X0_M5_g
+ N_VDD_X9_X7_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X7_X1_M0 X9_X7_X1_7 N_X9_X7_7_X9_X7_X1_M0_g N_X9_X7_X1_6_X9_X7_X1_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X7_X1_M1 N_GROUND_X9_X7_X1_M1_d N_X9_21_X9_X7_X1_M1_g X9_X7_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X7_X1_M2 N_X9_23_X9_X7_X1_M2_d N_X9_X7_X1_6_X9_X7_X1_M2_g
+ N_GROUND_X9_X7_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X7_X1_M3 N_X9_X7_X1_6_X9_X7_X1_M3_d N_X9_X7_7_X9_X7_X1_M3_g
+ N_VDD_X9_X7_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X7_X1_M4 N_VDD_X9_X7_X1_M4_d N_X9_21_X9_X7_X1_M4_g
+ N_X9_X7_X1_6_X9_X7_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X7_X1_M5 N_X9_23_X9_X7_X1_M5_d N_X9_X7_X1_6_X9_X7_X1_M5_g
+ N_VDD_X9_X7_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X8_X0_M0 X9_X8_X0_7 N_X9_19_X9_X8_X0_M0_g N_X9_X8_X0_6_X9_X8_X0_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X8_X0_M1 N_GROUND_X9_X8_X0_M1_d N_OP1_X9_X8_X0_M1_g X9_X8_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X8_X0_M2 N_X9_X8_7_X9_X8_X0_M2_d N_X9_X8_X0_6_X9_X8_X0_M2_g
+ N_GROUND_X9_X8_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X8_X0_M3 N_X9_X8_X0_6_X9_X8_X0_M3_d N_X9_19_X9_X8_X0_M3_g
+ N_VDD_X9_X8_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X8_X0_M4 N_VDD_X9_X8_X0_M4_d N_OP1_X9_X8_X0_M4_g N_X9_X8_X0_6_X9_X8_X0_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X8_X0_M5 N_X9_X8_7_X9_X8_X0_M5_d N_X9_X8_X0_6_X9_X8_X0_M5_g
+ N_VDD_X9_X8_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X8_X1_M0 X9_X8_X1_7 N_X9_X8_7_X9_X8_X1_M0_g N_X9_X8_X1_6_X9_X8_X1_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X8_X1_M1 N_GROUND_X9_X8_X1_M1_d N_X9_21_X9_X8_X1_M1_g X9_X8_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X8_X1_M2 N_X9_26_X9_X8_X1_M2_d N_X9_X8_X1_6_X9_X8_X1_M2_g
+ N_GROUND_X9_X8_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X8_X1_M3 N_X9_X8_X1_6_X9_X8_X1_M3_d N_X9_X8_7_X9_X8_X1_M3_g
+ N_VDD_X9_X8_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X8_X1_M4 N_VDD_X9_X8_X1_M4_d N_X9_21_X9_X8_X1_M4_g
+ N_X9_X8_X1_6_X9_X8_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X8_X1_M5 N_X9_26_X9_X8_X1_M5_d N_X9_X8_X1_6_X9_X8_X1_M5_g
+ N_VDD_X9_X8_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X9_X0_M0 X9_X9_X0_7 N_OP0_X9_X9_X0_M0_g N_X9_X9_X0_6_X9_X9_X0_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X9_X0_M1 N_GROUND_X9_X9_X0_M1_d N_OP1_X9_X9_X0_M1_g X9_X9_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X9_X0_M2 N_X9_X9_7_X9_X9_X0_M2_d N_X9_X9_X0_6_X9_X9_X0_M2_g
+ N_GROUND_X9_X9_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X9_X0_M3 N_X9_X9_X0_6_X9_X9_X0_M3_d N_OP0_X9_X9_X0_M3_g N_VDD_X9_X9_X0_M3_s
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X9_X0_M4 N_VDD_X9_X9_X0_M4_d N_OP1_X9_X9_X0_M4_g N_X9_X9_X0_6_X9_X9_X0_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X9_X0_M5 N_X9_X9_7_X9_X9_X0_M5_d N_X9_X9_X0_6_X9_X9_X0_M5_g
+ N_VDD_X9_X9_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X9_X1_M0 X9_X9_X1_7 N_X9_X9_7_X9_X9_X1_M0_g N_X9_X9_X1_6_X9_X9_X1_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X9_X1_M1 N_GROUND_X9_X9_X1_M1_d N_X9_21_X9_X9_X1_M1_g X9_X9_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X9_X1_M2 N_X9_27_X9_X9_X1_M2_d N_X9_X9_X1_6_X9_X9_X1_M2_g
+ N_GROUND_X9_X9_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X9_X1_M3 N_X9_X9_X1_6_X9_X9_X1_M3_d N_X9_X9_7_X9_X9_X1_M3_g
+ N_VDD_X9_X9_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X9_X1_M4 N_VDD_X9_X9_X1_M4_d N_X9_21_X9_X9_X1_M4_g
+ N_X9_X9_X1_6_X9_X9_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X9_X1_M5 N_X9_27_X9_X9_X1_M5_d N_X9_X9_X1_6_X9_X9_X1_M5_g
+ N_VDD_X9_X9_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X10_X0_M0 X9_X10_X0_7 N_X9_19_X9_X10_X0_M0_g N_X9_X10_X0_6_X9_X10_X0_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X10_X0_M1 N_GROUND_X9_X10_X0_M1_d N_X9_20_X9_X10_X0_M1_g X9_X10_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X10_X0_M2 N_X9_X10_7_X9_X10_X0_M2_d N_X9_X10_X0_6_X9_X10_X0_M2_g
+ N_GROUND_X9_X10_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X10_X0_M3 N_X9_X10_X0_6_X9_X10_X0_M3_d N_X9_19_X9_X10_X0_M3_g
+ N_VDD_X9_X10_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X10_X0_M4 N_VDD_X9_X10_X0_M4_d N_X9_20_X9_X10_X0_M4_g
+ N_X9_X10_X0_6_X9_X10_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X10_X0_M5 N_X9_X10_7_X9_X10_X0_M5_d N_X9_X10_X0_6_X9_X10_X0_M5_g
+ N_VDD_X9_X10_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X10_X1_M0 X9_X10_X1_7 N_X9_X10_7_X9_X10_X1_M0_g N_X9_X10_X1_6_X9_X10_X1_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X10_X1_M1 N_GROUND_X9_X10_X1_M1_d N_OP2_X9_X10_X1_M1_g X9_X10_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X10_X1_M2 N_X9_29_X9_X10_X1_M2_d N_X9_X10_X1_6_X9_X10_X1_M2_g
+ N_GROUND_X9_X10_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X10_X1_M3 N_X9_X10_X1_6_X9_X10_X1_M3_d N_X9_X10_7_X9_X10_X1_M3_g
+ N_VDD_X9_X10_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X10_X1_M4 N_VDD_X9_X10_X1_M4_d N_OP2_X9_X10_X1_M4_g
+ N_X9_X10_X1_6_X9_X10_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X10_X1_M5 N_X9_29_X9_X10_X1_M5_d N_X9_X10_X1_6_X9_X10_X1_M5_g
+ N_VDD_X9_X10_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X11_X0_M0 X9_X11_X0_7 N_OP0_X9_X11_X0_M0_g N_X9_X11_X0_6_X9_X11_X0_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X11_X0_M1 N_GROUND_X9_X11_X0_M1_d N_X9_20_X9_X11_X0_M1_g X9_X11_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X11_X0_M2 N_X9_X11_7_X9_X11_X0_M2_d N_X9_X11_X0_6_X9_X11_X0_M2_g
+ N_GROUND_X9_X11_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X11_X0_M3 N_X9_X11_X0_6_X9_X11_X0_M3_d N_OP0_X9_X11_X0_M3_g
+ N_VDD_X9_X11_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X11_X0_M4 N_VDD_X9_X11_X0_M4_d N_X9_20_X9_X11_X0_M4_g
+ N_X9_X11_X0_6_X9_X11_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X11_X0_M5 N_X9_X11_7_X9_X11_X0_M5_d N_X9_X11_X0_6_X9_X11_X0_M5_g
+ N_VDD_X9_X11_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X11_X1_M0 X9_X11_X1_7 N_X9_X11_7_X9_X11_X1_M0_g N_X9_X11_X1_6_X9_X11_X1_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X11_X1_M1 N_GROUND_X9_X11_X1_M1_d N_OP2_X9_X11_X1_M1_g X9_X11_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X11_X1_M2 N_X9_24_X9_X11_X1_M2_d N_X9_X11_X1_6_X9_X11_X1_M2_g
+ N_GROUND_X9_X11_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X11_X1_M3 N_X9_X11_X1_6_X9_X11_X1_M3_d N_X9_X11_7_X9_X11_X1_M3_g
+ N_VDD_X9_X11_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X11_X1_M4 N_VDD_X9_X11_X1_M4_d N_OP2_X9_X11_X1_M4_g
+ N_X9_X11_X1_6_X9_X11_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X11_X1_M5 N_X9_24_X9_X11_X1_M5_d N_X9_X11_X1_6_X9_X11_X1_M5_g
+ N_VDD_X9_X11_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X12_X0_M0 X9_X12_X0_7 N_X9_19_X9_X12_X0_M0_g N_X9_X12_X0_6_X9_X12_X0_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X12_X0_M1 N_GROUND_X9_X12_X0_M1_d N_OP1_X9_X12_X0_M1_g X9_X12_X0_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X12_X0_M2 N_X9_X12_7_X9_X12_X0_M2_d N_X9_X12_X0_6_X9_X12_X0_M2_g
+ N_GROUND_X9_X12_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X12_X0_M3 N_X9_X12_X0_6_X9_X12_X0_M3_d N_X9_19_X9_X12_X0_M3_g
+ N_VDD_X9_X12_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X12_X0_M4 N_VDD_X9_X12_X0_M4_d N_OP1_X9_X12_X0_M4_g
+ N_X9_X12_X0_6_X9_X12_X0_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X12_X0_M5 N_X9_X12_7_X9_X12_X0_M5_d N_X9_X12_X0_6_X9_X12_X0_M5_g
+ N_VDD_X9_X12_X0_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X12_X1_M0 X9_X12_X1_7 N_X9_X12_7_X9_X12_X1_M0_g N_X9_X12_X1_6_X9_X12_X1_M0_s
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X12_X1_M1 N_GROUND_X9_X12_X1_M1_d N_OP2_X9_X12_X1_M1_g X9_X12_X1_7
+ N_GROUND_X0_M0_b NMOS L=1.3e-07 W=1.2e-06
mX9_X12_X1_M2 N_PCSRC_X9_X12_X1_M2_d N_X9_X12_X1_6_X9_X12_X1_M2_g
+ N_GROUND_X9_X12_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X12_X1_M3 N_X9_X12_X1_6_X9_X12_X1_M3_d N_X9_X12_7_X9_X12_X1_M3_g
+ N_VDD_X9_X12_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X12_X1_M4 N_VDD_X9_X12_X1_M4_d N_OP2_X9_X12_X1_M4_g
+ N_X9_X12_X1_6_X9_X12_X1_M3_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X12_X1_M5 N_PCSRC_X9_X12_X1_M5_d N_X9_X12_X1_6_X9_X12_X1_M5_g
+ N_VDD_X9_X12_X1_M4_d N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X13_X0_M0 N_X9_X13_X0_6_X9_X13_X0_M0_d N_X9_23_X9_X13_X0_M0_g
+ N_GROUND_X9_X13_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X13_X0_M1 N_GROUND_X9_X13_X0_M1_d N_X9_22_X9_X13_X0_M1_g
+ N_X9_X13_X0_6_X9_X13_X0_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X13_X0_M2 N_X9_X13_7_X9_X13_X0_M2_d N_X9_X13_X0_6_X9_X13_X0_M2_g
+ N_GROUND_X9_X13_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X13_X0_M3 N_VDD_X9_X13_X0_M3_d N_X9_X13_X0_6_X9_X13_X0_M3_g
+ N_X9_X13_7_X9_X13_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X13_X0_M4 X9_X13_X0_7 N_X9_22_X9_X13_X0_M4_g N_VDD_X9_X13_X0_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X13_X0_M5 N_X9_X13_X0_6_X9_X13_X0_M5_d N_X9_23_X9_X13_X0_M5_g X9_X13_X0_7
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X13_X1_M0 N_X9_X13_X1_6_X9_X13_X1_M0_d N_X9_26_X9_X13_X1_M0_g
+ N_GROUND_X9_X13_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X13_X1_M1 N_GROUND_X9_X13_X1_M1_d N_X9_X13_7_X9_X13_X1_M1_g
+ N_X9_X13_X1_6_X9_X13_X1_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X13_X1_M2 N_X9_31_X9_X13_X1_M2_d N_X9_X13_X1_6_X9_X13_X1_M2_g
+ N_GROUND_X9_X13_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X13_X1_M3 N_VDD_X9_X13_X1_M3_d N_X9_X13_X1_6_X9_X13_X1_M3_g
+ N_X9_31_X9_X13_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X13_X1_M4 X9_X13_X1_7 N_X9_X13_7_X9_X13_X1_M4_g N_VDD_X9_X13_X1_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X13_X1_M5 N_X9_X13_X1_6_X9_X13_X1_M5_d N_X9_26_X9_X13_X1_M5_g X9_X13_X1_7
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X14_X0_M0 N_X9_X14_X0_6_X9_X14_X0_M0_d N_X9_27_X9_X14_X0_M0_g
+ N_GROUND_X9_X14_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X14_X0_M1 N_GROUND_X9_X14_X0_M1_d N_X9_31_X9_X14_X0_M1_g
+ N_X9_X14_X0_6_X9_X14_X0_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X14_X0_M2 N_X9_X14_7_X9_X14_X0_M2_d N_X9_X14_X0_6_X9_X14_X0_M2_g
+ N_GROUND_X9_X14_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X14_X0_M3 N_VDD_X9_X14_X0_M3_d N_X9_X14_X0_6_X9_X14_X0_M3_g
+ N_X9_X14_7_X9_X14_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X14_X0_M4 X9_X14_X0_7 N_X9_31_X9_X14_X0_M4_g N_VDD_X9_X14_X0_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X14_X0_M5 N_X9_X14_X0_6_X9_X14_X0_M5_d N_X9_27_X9_X14_X0_M5_g X9_X14_X0_7
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X14_X1_M0 N_X9_X14_X1_6_X9_X14_X1_M0_d N_X9_29_X9_X14_X1_M0_g
+ N_GROUND_X9_X14_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X14_X1_M1 N_GROUND_X9_X14_X1_M1_d N_X9_X14_7_X9_X14_X1_M1_g
+ N_X9_X14_X1_6_X9_X14_X1_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X14_X1_M2 N_X9_25_X9_X14_X1_M2_d N_X9_X14_X1_6_X9_X14_X1_M2_g
+ N_GROUND_X9_X14_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X14_X1_M3 N_VDD_X9_X14_X1_M3_d N_X9_X14_X1_6_X9_X14_X1_M3_g
+ N_X9_25_X9_X14_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X14_X1_M4 X9_X14_X1_7 N_X9_X14_7_X9_X14_X1_M4_g N_VDD_X9_X14_X1_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X14_X1_M5 N_X9_X14_X1_6_X9_X14_X1_M5_d N_X9_29_X9_X14_X1_M5_g X9_X14_X1_7
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X15_X0_M0 N_X9_X15_X0_6_X9_X15_X0_M0_d N_X9_27_X9_X15_X0_M0_g
+ N_GROUND_X9_X15_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X15_X0_M1 N_GROUND_X9_X15_X0_M1_d N_X9_26_X9_X15_X0_M1_g
+ N_X9_X15_X0_6_X9_X15_X0_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X15_X0_M2 N_X9_X15_7_X9_X15_X0_M2_d N_X9_X15_X0_6_X9_X15_X0_M2_g
+ N_GROUND_X9_X15_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X15_X0_M3 N_VDD_X9_X15_X0_M3_d N_X9_X15_X0_6_X9_X15_X0_M3_g
+ N_X9_X15_7_X9_X15_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X15_X0_M4 X9_X15_X0_7 N_X9_26_X9_X15_X0_M4_g N_VDD_X9_X15_X0_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X15_X0_M5 N_X9_X15_X0_6_X9_X15_X0_M5_d N_X9_27_X9_X15_X0_M5_g X9_X15_X0_7
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X15_X1_M0 N_X9_X15_X1_6_X9_X15_X1_M0_d N_X9_29_X9_X15_X1_M0_g
+ N_GROUND_X9_X15_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X15_X1_M1 N_GROUND_X9_X15_X1_M1_d N_X9_X15_7_X9_X15_X1_M1_g
+ N_X9_X15_X1_6_X9_X15_X1_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X15_X1_M2 N_X9_28_X9_X15_X1_M2_d N_X9_X15_X1_6_X9_X15_X1_M2_g
+ N_GROUND_X9_X15_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X15_X1_M3 N_VDD_X9_X15_X1_M3_d N_X9_X15_X1_6_X9_X15_X1_M3_g
+ N_X9_28_X9_X15_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X15_X1_M4 X9_X15_X1_7 N_X9_X15_7_X9_X15_X1_M4_g N_VDD_X9_X15_X1_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X15_X1_M5 N_X9_X15_X1_6_X9_X15_X1_M5_d N_X9_29_X9_X15_X1_M5_g X9_X15_X1_7
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X16_X0_M0 N_X9_X16_X0_6_X9_X16_X0_M0_d N_X9_24_X9_X16_X0_M0_g
+ N_GROUND_X9_X16_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X16_X0_M1 N_GROUND_X9_X16_X0_M1_d N_X9_27_X9_X16_X0_M1_g
+ N_X9_X16_X0_6_X9_X16_X0_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X16_X0_M2 N_X9_X16_7_X9_X16_X0_M2_d N_X9_X16_X0_6_X9_X16_X0_M2_g
+ N_GROUND_X9_X16_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X16_X0_M3 N_VDD_X9_X16_X0_M3_d N_X9_X16_X0_6_X9_X16_X0_M3_g
+ N_X9_X16_7_X9_X16_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X16_X0_M4 X9_X16_X0_7 N_X9_27_X9_X16_X0_M4_g N_VDD_X9_X16_X0_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X16_X0_M5 N_X9_X16_X0_6_X9_X16_X0_M5_d N_X9_24_X9_X16_X0_M5_g X9_X16_X0_7
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X16_X1_M0 N_X9_X16_X1_6_X9_X16_X1_M0_d N_PCSRC_X9_X16_X1_M0_g
+ N_GROUND_X9_X16_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X16_X1_M1 N_GROUND_X9_X16_X1_M1_d N_X9_X16_7_X9_X16_X1_M1_g
+ N_X9_X16_X1_6_X9_X16_X1_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X16_X1_M2 N_ALUSRC_X9_X16_X1_M2_d N_X9_X16_X1_6_X9_X16_X1_M2_g
+ N_GROUND_X9_X16_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X16_X1_M3 N_VDD_X9_X16_X1_M3_d N_X9_X16_X1_6_X9_X16_X1_M3_g
+ N_ALUSRC_X9_X16_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X16_X1_M4 X9_X16_X1_7 N_X9_X16_7_X9_X16_X1_M4_g N_VDD_X9_X16_X1_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X16_X1_M5 N_X9_X16_X1_6_X9_X16_X1_M5_d N_PCSRC_X9_X16_X1_M5_g X9_X16_X1_7
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X17_X0_M0 N_X9_X17_X0_6_X9_X17_X0_M0_d N_X9_29_X9_X17_X0_M0_g
+ N_GROUND_X9_X17_X0_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X17_X0_M1 N_GROUND_X9_X17_X0_M1_d N_X9_23_X9_X17_X0_M1_g
+ N_X9_X17_X0_6_X9_X17_X0_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X17_X0_M2 N_X9_X17_7_X9_X17_X0_M2_d N_X9_X17_X0_6_X9_X17_X0_M2_g
+ N_GROUND_X9_X17_X0_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X17_X0_M3 N_VDD_X9_X17_X0_M3_d N_X9_X17_X0_6_X9_X17_X0_M3_g
+ N_X9_X17_7_X9_X17_X0_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X17_X0_M4 X9_X17_X0_7 N_X9_23_X9_X17_X0_M4_g N_VDD_X9_X17_X0_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X17_X0_M5 N_X9_X17_X0_6_X9_X17_X0_M5_d N_X9_29_X9_X17_X0_M5_g X9_X17_X0_7
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X17_X1_M0 N_X9_X17_X1_6_X9_X17_X1_M0_d N_X9_24_X9_X17_X1_M0_g
+ N_GROUND_X9_X17_X1_M0_s N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X17_X1_M1 N_GROUND_X9_X17_X1_M1_d N_X9_X17_7_X9_X17_X1_M1_g
+ N_X9_X17_X1_6_X9_X17_X1_M0_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X17_X1_M2 N_X9_30_X9_X17_X1_M2_d N_X9_X17_X1_6_X9_X17_X1_M2_g
+ N_GROUND_X9_X17_X1_M1_d N_GROUND_X0_M0_b NMOS L=1.3e-07 W=6e-07
mX9_X17_X1_M3 N_VDD_X9_X17_X1_M3_d N_X9_X17_X1_6_X9_X17_X1_M3_g
+ N_X9_30_X9_X17_X1_M3_s N_VDD_X0_M3_b PMOS L=1.3e-07 W=1.35e-06
mX9_X17_X1_M4 X9_X17_X1_7 N_X9_X17_7_X9_X17_X1_M4_g N_VDD_X9_X17_X1_M3_d
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
mX9_X17_X1_M5 N_X9_X17_X1_6_X9_X17_X1_M5_d N_X9_24_X9_X17_X1_M5_g X9_X17_X1_7
+ N_VDD_X0_M3_b PMOS L=1.3e-07 W=2.7e-06
*
.include "top.pex.netlist.TOP.pxi"
*
.End
*
*
